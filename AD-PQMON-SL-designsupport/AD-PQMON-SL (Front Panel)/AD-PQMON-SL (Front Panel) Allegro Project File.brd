# Allegro board AD-PQMON-SL (Front Panel) Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UNNAMED_9_CAP_I113_N1: length 2.1
  TOP w0.305: C32.1 47.03,32.89 U1.10
UNNAMED_9_CAP_I115_N1: length 2.1
  TOP w0.305: C1.1 33.53,32.93 U1.1
UNNAMED_9_CAP_I116_N1: length 2.1
  BOTTOM w0.305: U1.6 41.03,36.53 C34.1
UNNAMED_9_CAP_I116_N2: length 2.1
  BOTTOM w0.305: U1.7 42.53,36.63 C34.2
UNNAMED_9_CAP_I118_N1: length 2
  TOP w0.305: U1.2 35.03,32.8 C2.1
UNNAMED_9_CAP_I120_N1: length 2
  TOP w0.305: C101.1 36.53,33.68 U1.3
UNNAMED_9_CAP_I122_N1: length 2
  TOP w0.305: U1.4 38.03,32.8 C105.1
UNNAMED_9_CAP_I124_N1: length 2.1
  TOP w0.305: U1.5 39.53,32.93 C106.1
UNNAMED_9_DIOLED_I33_N: length 3
  TOP w0.203: DS10.C R102.1
UNNAMED_9_DIOLED_I42_N: length 3.1
  TOP w0.203: R105.1 53.45,82.42 53.7,82.68 DS11.C
UNNAMED_9_FERRITE_I154_N1: length 21.1
  BOTTOM w0.305: R29.2 R28.2 R27.2 R20.2 R19.2 R18.2 R16.2 12.54,40.77 12.38,40.93 E3.1 E4.1 7.87,39.98 7.87,39.97 C10.1
UNNAMED_9_MODNHDC12832A1Z_I128_LED: length 5.8
  TOP w0.305: JP4.2 62.83,30.95 U1.K
UNNAMED_9_MODNHDC12832A1Z_I128_LED_1: length 6.3
  BOTTOM w0.305: v1(26.92,30.86) 26.92,32.89 28.23,34.2 U1.A
UNNAMED_9_NC3PJMPR_I132_B: length 2.4
  TOP w0.305: R17.2 28.75,31.71 28.45,31.41 JP3.3
VISOIN: length 21.3
  BOTTOM w0.305: C8.2 8.52,50.18 9.26,50.92 C9.1 9.91,50.93 10.41,51.44 11.89,51.44 U2.12 13.46,51.56 14.24,52.34 14.24,60.15 13.93,60.45 9.82,60.45 C4.1 9.55,60.19 C3.2
XTAL_I: length 4.9
  TOP w0.152: U8.8 48.28,80.54 C50.1 48.04,82.32 Y1.1
XTAL_O: length 5.7
  TOP w0.152: U8.9 47.78,78.84 45.31,81.31 C51.1 46.2,82.45 Y1.3

## Copper pours and planes (outline as drawn)
3V3 on L3_PWR: 0.89,85.98 81.53,85.98 81.53,0.89 0.89,0.89
AGND1 on BOTTOM: 14.99,63.12 15.24,62.87 15.24,49.66 14.48,48.9 5.84,48.9 5.84,49.66 5.59,49.91 0.76,49.91 0.51,50.16 0.51,63.12
DGND on TOP: 35.81,86.61 82.17,86.61 82.17,0.25 0.25,0.25 0.25,47.12 19.05,47.12 19.05,67.95 35.81,67.95 ; 1 cut-out
DGND on BOTTOM: 35.81,86.61 82.17,86.61 82.17,0.25 0.25,0.25 0.25,47.12 19.05,47.12 19.05,67.95 35.81,67.95
DGND on L2_GND: 0.25,86.61 82.17,86.61 82.17,0.25 0.25,0.25

## Text on the board
User.Comments: 7.    ADD SOLDER BLOB FOR PINS 1 & 2 ON THE FOLLOWING LOCATIONS: | 6.    SMOOTHEN EDGES AND FREE FROM BURRS AFTER DEPANELIZATION PROCESS. | 5.    BOARDS TO BE SHIPPED SINGULATED AFTER ASSEMBLY PROCESS. | 2.    REPAIRS PER IPC-7711/21(LATEST REVISION) ARE ALLOWED. | 3.    REPAIRS ARE NOT ALLOWED IN SOLDERMASK FREE AREAS ON EITHER | SIDE OF THE BOARD. | 4.    RoHS COMPLIANCE: ASSEMBLY VENDOR SHOULD ASSURE COMPLIANCE | WITH LEAD-FREE AND RoHS PCB ASSEMBLY STANDARDS (EU RoHS | DIRECTIVE 2002/95/EC). | - JP3 | - JP4 | DETAIL B | MARKING
Ref Des/Assembly Top: C | A | MATE ENTRY
Ref Des/Silkscreen Top: ADE9430 | C | A
PAGE_OUTLINE: FAB NOTES REVISION: 2ND NOVEMBER 2022 | 31JAN24 | 8.   IMPEDANCE REQUIREMENTS: IF NO STACKUP IS DEFINED, THE VENDOR IS ALLOWED TO ADJUST THE DIELECTRIC | 13.  PLATING SPECIFICATION: | 1.   DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | ALL DOCUMENTS & SPECIFICATIONS REFERRED TO BELOW SHOULD BE THE LATEST REVISIONS. | 2.  BOARD MATERIAL:(USE CHECKED ITEMS) | 3.   ALL LAMINATES & BONDING MATERIALS SHOULD BE SELECTED FROM IPC-4101 OR IPC-4103,(TG>170 DEGC TD>300 DEGC) | 4.   REFER TO IPC-6010 SERIES, CLASS 2 FOR FABRICATION. | 5.   REFER TO LAMINATION DIAGRAM FOR OVERALL BOARD THICKNESS, TOLERANCE APPLIES AFTER ALL LAMINATION AND PLATING | 6.   BOW & TWIST NOT TO EXCEED 0.0075 INCHES (0.75%) PER LINEAR INCH AND SHOULD BE MEASURED PER IPC-TM-650, METHOD 2.4.22. | 7.   ACCEPTABILITY PER ADI SPECIFICATION TST00115. | 9.   FILLET OPTIONS TO ENHANCE RELIABILITY AT PAD JUNCTIONS WHERE SPACING PERMITS. | 10.  THIEVING: | 11.  LAYER TO LAYER REGISTRATION SHALL BE WITHIN 0.003 INCHES. | 12.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN 0.005 INCHES DTP,UNLESS SPECIFIED. | 14.  SURFACE FINISH: | 15.  SOLDERMASK: | 16.  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, EPOXY BASED INK PER ARTWORK. | (X) WHITE | ( ) OTHER | PROCESSES. FINISHED THICKNESS MEASURED FROM TOP COPPER TO BOTTOM COPPER. | (X)  ISOLA 370HR OR S1000-2 OR IT180 OR EQUIVALENT | ( )  ISOLA-FR408HR OR EQUIVALENT | ( )  ISOLA IS410 | ( )  MEGTRON 6 | ( )  NELCO-4000-13 | ( )  ROGERS 4350B | ( ) ROGERS 3003 | ( ) ARLON 85N | ( ) EM370D | ( )  OTHER ________________________ | ( ) FILLETS ALLOWED | (X) FILLETS NOT ALLOWED | ( ) VENDOR MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS MAINTAINING A MINIMUM | (X) VENDOR MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS. | (X) LPI | ( ) OTHER_________ | COLOR | (X) GREEN | HINDER PROPER SOLDER WICKING. BARREL RELIEF ON SOLDERMASK ALLOWED IN UNFILLED VIA IN PAD HOLES. | (X) REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIRMENTS | (X) IMMERSION GOLD (ENIG) 1.58-3.94 MICRO INCHES OVER 118-236 MICRO INCHES MIN. OF ELECTROLESS NICKEL PER IPC-4552 | ( ) OSP (ORGANIC SOLDERABILITY PRESERVATIVE) | ( ) IMMERSION SILVER | ( ) SOFT WIRE BONDABLE GOLD 30-50 MICRO INCHES OF SOFT WIRE | ( ) EDGE CONNECTOR FINGERS ARE TO BE PLATED WITH 100 MICRO-INCHES(.0001") OF LOW STRESS | THICKNESS & TRACE WIDTHS TO MEET THE IMPEDANCE REQUIREMENT. IF SPECIFIED, THE VENDOR MUST | TRACE WIDTH & SPACING THAT IMPACT THE REQUIREMENTS MUST HAVE WRITTEN APPROVAL FROM ADI. | MINIMUM BARREL PLATING OF 0.001 INCHES. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR SO AS TO | SOLDERMASK OVER BARE COPPER OR BARE GOLD (BOTH SIDES) TO MEET IPC-SM-840. | IF PRESENT,DO NOT MODIFY SOLDERMASK DEFINED PADS (MASK OPENINGS LESS THAN COPPER PAD) WITHOUT APPROVAL. | MEET THE REQUIREMENTS LISTED IN THE IMPEDANCE TABLE. ANY ADJUSTMENT MADE TO THE DEFINED STACKUP, | UL FLAMMABILITY RATING 94V-0. BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796/UL796F. | BONDABLE GOLD OVER 100-150 MICRO INCHES OF NICKEL | NICKEL UNDER 30 MICRO-INCHES (.0003') OF GOLD | 0.100 INCH CLEARANCE FROM ALL COPPER FEATURES, | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. | UNLESS OTHERWISE SPECIFIED | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLAINT WITH THE EU DIRECTIVE 2002/95/EC | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2. | 21.  INTENTIONAL SHORTS: | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 22.  PEMNUTS: | 23.  MANUFACTURER TO ETCH/STAMP WITH PERMANENT NON-CONDUCTIVE INK | ON SECONDARY SIDE UNLESS OTHERWISE SPECIFIED: | 18.  A TIME DOMAIN REFLECTOMETER REPORT (TDR) FOR EACH IMPEDANCE CONTROLLED LAYER & A CERTIFICATE | 19.  IF PRESENT, ALL BLIND/BURIED VIAS WITH AN ASPECT RATIO <1:1 TO BE PLATED SHUT WITH COPPER WHEN | 20.  FOR VIA FILL INFORMATION REFER TO DRILL CHART: | 24. PANELIZATION: | 25.  MINIMUM DESIGN LINE WIDTH IS .006 INCH. | 26.  MINIMUM DESIGN LINE SPACING IS .005 INCH. | IS ACCEPTABLE, ALL OTHER INSTANCES MUST BE REPORTED. | IF AN INTENTIONAL SHORT REPORT IS SUPPLIED AND DOES NOT MATCH THE FAB DATA THEN | THE PCB SHALL HAVE A VERIFICATION STAMP. | (X)  NON-CONDUCTIVE EPOXY FILL ALL DRILLED VIAS | ( )  COPPER FILL ALL 0.XXXX INCHES DRILLED VIAS | ( ) PEMNUTS TO BE INSTALLED BY FABRICATOR | ( ) PEMNUTS NOT TO BE INSTALLED BY FABRICATOR | (X) NOT APPLICABLE | USED AS VIA-IN-PAD OR AS A STACKED VIA. BLIND/BURIED VIAS WITH AN ASPECT RATIO >1:1 TO BE FILLED | A. UL CODE-FLAMMABILITY RATING FOR THOSE APPROVED MATERIALS(IF APPLICABLE) | B. DATE CODE | C. LOT NUMBER | D. MANUFACTURER LOGO | BOARDS TO BE SHIPPED IN ARRAY AND KEPT INTACT | PANEL TO BE SUBJECTED TO CUSTOMERS APPROVAL | PANEL SOLDER PASTE STENCIL GERBER TO BE PROVIDED TO ANALOG | CAN'T BE PERFORMED BECAUSE THE TRACE LENGTH IS TOO SHORT ON THE OUTER LAYERS AT THE PIN ESCAPES | ADI APPROVAL IS REQUIRED. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. INSTANCES WHERE TDR TESTING | WITH NON-CONDUCTIVE EPOXY. | 4-LAYER STACKUP | NOTES: | TOOLING: | FINISH: | MATERIAL: | TESTING: | MISCELLANEOUS: | CUSTOMER EVAL Z
DIMENSION: LABEL PLACEMENT INFORMATION | HALF SIZE LABELS ARE | AVAILABLE IN THE LIBRARY | PLACE WHEELIE BIN LOGO | TO SUIT THE LAYOUT. | PLACE ROHS COMPLIANT LOGO | TO SUIT THE LAYOUT OR | DELETE IF NOT REQ'D. | PLACE CHINA ROHS COMPLIANT | LOGO TO SUIT THE LAYOUT OR | 1.THE BOARD SIZE CAN BE ADJUSTED TO SUIT THE APPLICATION. | 2.THE MOUNTING HOLES CAN BE MOVED/REMOVED TO SUIT THE APPLICATION. | 3.THE FIDUCIALS CAN BE MOVED TO SUIT THE APPLICATION. | 4.ADJUST THE DIMENSIONS TO SUIT THE APPLICATION. | 5.ADD THE CORRECT LAYER STACKUP ON FAB2 BASED ON THE NO OF LAYERS ON THE PCB. | 6.THE ROHS COMPLIANT AND WHEELIE BIN LOGO'S CAN BE MOVED TO THE DESIRED LOCATION. | HALF SIZE VERSIONS OF THE LABELS ARE AVAILABLE IN THE LIBRARY. | NOTES FOR TEMPLATE USAGE. | (REF) | DIA MAX | _ | " " | GENERIC D-SIZE TEMPLATE BR-067706A
User.9: 08-      -09
User.11: 1 | 2 | 3 | A | C | SEE DETAIL B | SEE DETAIL A
User.22: DAUGHTER BOARD OUTLINE | REFERENCE ONLY
User.45: FIGURE | SIZE | 10.0 | 30.0 | 35.0 | 45.0 | 55.0 | 65.0 | 40.0 | 41.0 | 135.0 | PLATED | NON-PLATED | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | QTY | 272 | 1 | 17 | 35 | 4 | 6 | 2 | 5 | TOLERANCE/NOTES
