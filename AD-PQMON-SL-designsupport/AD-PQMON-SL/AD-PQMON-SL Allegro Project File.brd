# Allegro board AD-PQMON-SL Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DVDDOUT: length 4.5
  TOP w0.152: U1.3 34.1,37.25 C47.2 34.07,36 C43.2
GND: length 265.6
  TOP w0.203: 34.05,47.18 34.05,47.48 v1(34.58,48.01) 35.14,47.46 35.14,47.18 ; 34.05,47.18 34.05,46.11 U1.28 ; 34.05,47.18 34.13,47.18 34.36,47.41 ; 35.14,47.18 35.14,46.11 U1.26 ; 35.14,47.18 35.04,47.18 34.81,47.41
  TOP w0.305: v1(35.35,43.06) 35.1,43.31 ; v1(35.35,43.06) 36.1,43.81 ; v1(35.35,43.06) 35.6,42.81 U1.15 39.28,42.81 v1(39.28,42.81) ; v1(35.35,43.06) 34.6,42.31 ; 35.1,43.31 U1.26 ; 35.1,43.31 v1(34.33,44.08) 34.1,44.31 U1.28 ; U4.17 47.41,43.54 v1(47.21,43.34) ; 34.6,42.31 U1.4 v1(34.6,38.76) ; 34.6,42.31 v1(34.33,42.05) 33.6,41.31 U1.2 33.6,38.82 33.37,38.59 v1(33.37,38.57) ; R81.1 v1(38.78,36.71) ; U4.27 53.91,43.67 v1(53.58,43.34) ; 36.1,43.81 U1.17 39.06,43.81 v1(39.27,44.03) 38.99,44.31 U1.18 36.6,44.31 v1(36.36,44.08) 36.1,43.81 ; U4.19 48.71,43.54 v1(48.91,43.34) ; R19.2 v1(40.68,13.6) R11.1
  TOP w0.406: 9.82,19.44 Q1.3 ; Q1.3 9.82,21.42 ; Q1.3 10.62,20.43 ; Q1.3 9.02,20.43 ; 3.85,23.13 C15.2 ; C15.2 5.88,23.13 ; C15.2 4.87,24 ; 43.3,44.14 C41.1 44.08,43.38 ; 2.78,45.22 LED3.C ; LED3.C 3.56,44.55 ; LED3.C 3.56,45.89 ; 33.66,13.62 Q6.3 ; Q6.3 34.46,14.61 ; Q6.3 34.46,12.63 ; Q6.3 35.26,13.62 ; R20.1 52.35,13.6 ; R20.1 51.54,12.61 ; R20.1 50.72,13.6 ; R20.1 51.54,14.59 ; 58.71,38.15 R42.2 ; R42.2 59.5,38.83 ; R42.2 57.93,38.83 ; R42.2 58.71,39.52 ; 4.25,13.6 R1.2 ; R1.2 5.06,14.59 ; R1.2 5.87,13.6 ; R1.2 5.06,12.61 ; 14.13,47.51 C6.1 ; C6.1 13.26,48.52 ; C6.1 14.13,49.54 ; 54.21,38.67 C7.2 ; C7.2 55.15,39.76 ; C7.2 54.21,40.85 ; 3.56,46.2 LED2.C ; LED2.C 3.56,47.55 ; LED2.C 2.78,46.87 ; TP21.1 19.6,51.1 ; TP21.1 18.54,50.05 ; TP21.1 20.65,50.05 ; TP21.1 19.6,48.99 ; C22.1 39.41,24 ; C22.1 38.39,23.13 ; C22.1 40.43,23.13 ; R4.1 26.9,14.59 ; R4.1 26.9,12.61 ; R4.1 26.09,13.6 ; R4.1 27.71,13.6 ; C19.2 20.23,26.82 ; C19.2 19.22,27.68 ; C19.2 18.2,26.82 ; TP22.1 5.03,17.28 ; TP22.1 3.98,16.23 ; TP22.1 3.98,18.34 ; TP22.1 2.92,17.28 ; C21.2 30.52,23.13 ; C21.2 28.49,23.13 ; C21.2 29.5,24 ; C47.1 33.07,37.84 ; C47.1 33.07,36.6 ; C47.1 32.48,37.22 ; Q9.3 46.78,14.61 ; Q9.3 45.98,13.62 ; Q9.3 46.78,12.63 ; Q9.3 47.58,13.62 ; C26.2 42.84,23.13 ; C26.2 41.82,24 ; C26.2 40.81,23.13 ; C24.2 31.54,27.68 ; C24.2 32.55,26.82 ; C24.2 30.52,26.82 ; C34.2 66.33,39.75 ; C34.2 67.35,38.88 ; C34.2 65.32,38.88 ; 30.36,47.25 C44.1 ; C44.1 31.6,47.25 ; C44.1 30.98,47.83 ; 26.04,47.14 v1(26.04,48.13) ; v1(26.04,48.13) 26.93,48.13 ; v1(26.04,48.13) 25.15,48.13 ; v1(26.04,48.13) 26.04,49.13 ; C16.1 14.77,24 ; C16.1 13.76,23.13 ; C16.1 15.79,23.13 ; 34.34,49.06 C46.1 34.92,48.43 ; 45.98,20.43 Q7.3 ; Q7.3 47.58,20.43 ; Q7.3 46.78,19.44 ; Q7.3 46.78,21.42 ; 34.46,19.44 Q5.3 ; Q5.3 35.26,20.43 ; Q5.3 33.66,20.43 ; Q5.3 34.46,21.42 ; 59.98,38.88 C36.2 ; C36.2 61,39.75 ; C36.2 62.02,38.88 ; 34.32,49.54 C42.1 ; C42.1 34.32,51.11 ; C42.1 33.56,50.33 ; 90.18,38.83 R29.2 ; R29.2 90.97,39.52 ; R29.2 91.76,38.83 ; C31.2 43.86,27.68 ; C31.2 42.84,26.82 ; C31.2 44.87,26.82 ; 3.56,39.59 LED5.C ; LED5.C 2.78,40.27 ; LED5.C 3.56,40.94 ; 67.83,38.83 R40.2 ; R40.2 68.62,39.52 ; R40.2 69.41,38.83 ; 5.88,26.82 C29.2 ; C29.2 6.9,27.68 ; C29.2 7.92,26.82 ; Q2.3 9.82,14.61 ; Q2.3 9.82,12.63 ; Q2.3 9.02,13.62 ; Q2.3 10.62,13.62 ; C18.1 28.11,23.13 ; C18.1 26.08,23.13 ; C18.1 27.09,24 ; 28.3,16.23 TP27.1 ; TP27.1 28.3,18.34 ; TP27.1 27.25,17.28 ; TP27.1 29.36,17.28 ; C20.1 25.06,27.68 ; C20.1 26.08,26.82 ; C20.1 24.04,26.82 ; 75.73,39.75 C35.2 74.72,38.88 ; R19.2 42.02,14.59 ; R19.2 42.02,12.61 ; R19.2 42.83,13.6 ; v1(27.94,50.33) 28.83,50.33 ; v1(27.94,50.33) 27.05,50.33 ; v1(27.94,50.33) 27.94,51.33 ; 29.7,12.61 R10.2 ; R10.2 28.88,13.6 ; R10.2 29.7,14.59 ; R10.2 30.51,13.6 ; Q4.3 22.14,14.61 ; Q4.3 21.34,13.62 ; Q4.3 22.94,13.62 ; Q4.3 22.14,12.63 ; C25.1 37.38,27.68 ; C25.1 38.4,26.82 ; C25.1 36.36,26.82 ; 29.45,46.93 C37.2 30.08,47.51 ; TP28.1 17.03,17.28 ; TP28.1 15.97,16.23 ; TP28.1 14.92,17.28 ; TP28.1 15.97,18.34 ; R33.2 83.23,39.52 ; R33.2 84.01,38.83 ; R33.2 82.44,38.83 ; Q3.3 22.14,21.42 ; Q3.3 22.94,20.43 ; Q3.3 21.34,20.43 ; Q3.3 22.14,19.44 ; 78.91,39.75 C33.2 79.92,38.88 ; R3.2 17.38,14.59 ; R3.2 16.57,13.6 ; R3.2 18.19,13.6 ; R3.2 17.38,12.61 ; 84.5,38.88 C27.2 85.51,39.75 ; 32.01,35.7 C43.1 ; C43.1 32.77,36.48 ; C43.1 32.77,34.91 ; 48.68,26.82 C32.1 ; C32.1 49.7,27.68 ; C32.1 50.71,26.82 ; 80.41,38.83 R32.2 ; R32.2 81.19,39.52 ; R32.2 81.98,38.83 ; R2.1 14.58,14.59 ; R2.1 15.39,13.6 ; R2.1 13.77,13.6 ; R2.1 14.58,12.61 ; 28.83,50.42 C38.2 ; C38.2 29.45,51 ; C38.2 30.08,50.42 ; 38.4,13.6 R11.1 ; R11.1 39.22,14.59 ; R11.1 39.22,12.61 ; C28.1 51.73,24 ; C28.1 50.71,23.13 ; C28.1 52.75,23.13 ; C40.1 26.11,45.73 ; C40.1 26.11,44.15 ; C40.1 25.35,44.94 ; 72.66,38.83 R41.2 ; R41.2 74.23,38.83 ; R41.2 73.45,39.52 ; 45.52,39.89 C5.1 ; C5.1 46.38,38.87 ; C5.1 46.38,40.9 ; 37.72,35.92 R81.1 ; R81.1 37.03,36.71 ; R81.1 37.72,37.5 ; C30.1 13.76,26.82 ; C30.1 11.72,26.82 ; C30.1 12.74,27.68 ; 30.04,37.13 C39.2 29.25,37.89 ; C17.2 17.19,24 ; C17.2 18.2,23.13 ; C17.2 16.17,23.13 ; 89.7,38.88 C23.2 88.69,39.75
  TOP w0.508: C45.1 42,43.7
  L2_GND w0.406: 3.98,16.23 TP22.1 ; TP22.1 3.98,18.34 ; TP22.1 2.92,17.28 ; TP22.1 5.03,17.28 ; TP27.1 29.36,17.28 ; TP27.1 28.3,18.34 ; TP27.1 28.3,16.23 ; TP27.1 27.25,17.28 ; 15.97,16.23 TP28.1 ; TP28.1 17.03,17.28 ; TP28.1 15.97,18.34 ; TP28.1 14.92,17.28 ; 18.54,50.05 TP21.1 ; TP21.1 20.65,50.05 ; TP21.1 19.6,51.1 ; TP21.1 19.6,48.99
  BOTTOM w0.406: 15.97,16.23 TP28.1 ; TP28.1 14.92,17.28 ; TP28.1 17.03,17.28 ; TP28.1 15.97,18.34 ; TP21.1 20.65,50.05 ; TP21.1 19.6,48.99 ; TP21.1 19.6,51.1 ; TP21.1 18.54,50.05 ; 28.3,16.23 TP27.1 ; TP27.1 28.3,18.34 ; TP27.1 29.36,17.28 ; TP27.1 27.25,17.28 ; 58.46,16.99 L4.2 59.48,17.88 ; 3.98,16.23 TP22.1 ; TP22.1 2.92,17.28 ; TP22.1 3.98,18.34 ; TP22.1 5.03,17.28
  vias: v1(2.2,46.87) v1(2.2,45.22) v1(2.61,40.27) v1(2.92,50.55) v1(2.92,35.31) v1(2.92,27.69) v1(2.92,20.07) v1(2.92,12.45) v1(2.92,4.83) v1(3.67,23.12) v1(3.85,13.6) v1(4.23,49.67) v1(4.66,31.53) v1(4.84,24.19) v1(4.83,16.26) v1(4.83,8.64) v1(5.04,14.77) v1(6.73,35.31) v1(6.73,4.83) v1(6.9,28.08) v1(8.09,26.81) v1(8.64,23.88) v1(9.82,21.6) v1(9.85,19.26) v1(9.82,14.79) v1(9.82,12.58) v1(10.54,35.31) v1(10.54,12.45) v1(10.54,4.83) v1(11.55,26.81) v1(12.33,48.7) v1(12.45,39.12) v1(12.45,16.26) v1(12.74,28.08) v1(12.94,41.74) v1(13.6,31.45) v1(14.35,27.69) v1(14.35,20.07) v1(14.35,4.83) v1(14.47,49.69) v1(14.57,14.77) v1(14.77,24.16) v1(15.97,23.15) v1(16.04,13.6) v1(16.26,39.12) v1(16.26,8.64) v1(17.19,24.16) v1(17.39,14.77) v1(17.54,41.89) v1(18.16,50.55) v1(18.16,20.07) v1(18.16,4.83) v1(19.22,28.08) v1(19.9,31.43) v1(20.07,46.74) v1(20.07,39.12) v1(20.39,26.83) v1(21.97,50.55) v1(21.97,35.31) v1(21.97,4.83) v1(22.14,21.6) v1(22.09,19.24) v1(22.14,14.79) v1(22.14,12.45) v1(23.1,47.91) v1(23.87,26.81) v1(23.88,23.88) v1(25.06,27.85) v1(25.78,35.31) v1(25.78,4.83) v1(26.1,46.03) v1(26.91,14.77) v1(27.09,24.16) v1(27.17,40.32) v1(27.69,8.64) v1(28.18,31.48) v1(28.29,23.15) v1(28.36,13.6) v1(29.25,38.24) v1(29.5,24.16) v1(29.59,20.07) v1(29.59,4.83) v1(29.68,14.77) v1(30.24,50.43) v1(31.54,27.85) v1(31.5,16.26) v1(31.77,50.96) v1(31.77,47.25) v1(32.17,37.22) v1(32.71,26.81) v1(32.78,34.73) v1(33.31,45.09) v1(33.31,44.08) v1(33.31,43.06) v1(33.31,42.05) v1(33.31,41.03) v1(33.39,50.33) v1(33.4,20.07) v1(33.4,12.45) v1(33.4,4.83) v1(34.33,45.09) v1(34.33,43.06) v1(34.33,41.03) v1(34.46,21.6) v1(34.46,19.29) v1(34.46,14.79) v1(34.46,12.45) v1(35.35,45.09) v1(35.35,44.08) v1(35.35,42.05) v1(35.35,41.03) v1(35.31,31.5) v1(35.31,23.88) v1(35.31,8.64) v1(36.21,26.81) v1(36.36,45.09) v1(36.36,43.06) v1(36.36,42.05) v1(36.36,41.03) v1(37.25,49.84) v1(37.21,4.83) v1(37.38,45.09) v1(37.38,44.08) v1(37.38,43.06) v1(37.38,42.05) v1(37.38,41.03) v1(37.4,27.85) v1(38.37,48.98) v1(39.12,16.26) v1(39.12,8.64) v1(39.23,14.77) v1(39.41,24.16) v1(40.6,23.15) v1(41.02,20.07) v1(41.02,12.45) v1(41.02,4.83) v1(41.49,43.82) v1(41.82,24.16) v1(42.03,14.77) v1(42.93,31.5) v1(42.93,16.26) v1(43.86,28.08) v1(44.26,43.39) v1(44.83,20.07) v1(44.83,12.45) v1(44.83,4.83) v1(45.05,26.83) v1(45.33,39.99) v1(46.12,43.34) v1(46.4,41.08) v1(46.74,23.88) v1(46.74,8.64) v1(46.78,21.6) v1(46.78,19.26) v1(46.78,14.79) v1(46.78,12.45) v1(48.5,26.83) v1(48.64,20.07) v1(48.64,12.45) v1(48.64,4.83) v1(49.7,28.08) v1(49.8,43.34) v1(50.55,31.5) v1(50.55,16.26) v1(51.53,14.77) v1(51.73,24.39) v1(52.45,35.31) v1(52.45,27.69) v1(52.45,20.07) v1(52.45,12.45) v1(52.45,4.83) v1(52.52,13.6) v1(52.92,23.12) v1(54.22,38.49) v1(54.36,31.5) v1(54.36,23.88) v1(55.67,39.76) v1(56.25,43.34) v1(56.26,35.31) v1(56.26,27.69) v1(56.26,20.07) v1(57.76,38.82) v1(58.17,31.5) v1(58.17,23.88) v1(58.28,16.98) v1(59.48,18.3) v1(59.76,38.85) v1(59.93,35.3) v1(59.93,27.68) v1(59.93,20.06) v1(61,39.91) v1(66.33,39.91) v1(67.66,40.98) v1(67.58,38.85) v1(68.62,39.68) v1(69.03,43.67) v1(69.6,39.12) v1(72.99,43.7) v1(73.45,39.68) v1(74.39,40.95) v1(74.46,38.87) v1(75.73,39.91) v1(78.91,39.91) v1(80.18,38.85) v1(81.19,39.68) v1(83.23,39.68) v1(83.28,42.88) v1(84.27,38.87) v1(85.51,39.91) v1(88.69,39.91) v1(89.93,38.87) v1(90.55,42.93) v1(90.97,39.68) v1(92.46,39.12)
VBAT: length 7.6
  TOP w0.635: BT1.P 21.64,75.94 21.03,76.55 R56.2
ADIN1110_RESET: length 29.2
  TOP w0.152: U2.121 v1(35.86,72.7) ; P2.24 v1(50.73,70.48)
  L3_PWR w0.152: v1(50.73,70.48) 49.74,69.48 49.74,68.63 49.39,68.28 44.49,68.28 43.63,69.15 40.45,69.15 37.99,66.68 v1(35.86,66.68)
  BOTTOM w0.152: v1(35.86,72.7) v1(35.86,66.68)
BTN_0: length 81.5
  TOP w0.152: v1(9.95,84.34) 9.95,83.88 10.84,82.99 10.84,71.05 9.31,69.53 v1(9.31,67.55) ; P2.7 46.73,59.14 46.19,58.61 45.3,58.61 43.7,60.21 41.8,60.21 39.19,62.82 v1(27.63,62.82) ; U2.94 v1(25.81,83.74)
  L3_PWR w0.152: v1(9.31,67.55) 9.31,65.57 10.63,64.25 13.12,64.25 15.66,61.71 25.47,61.71 26.58,62.82 v1(27.63,62.82)
  BOTTOM w0.152: v1(25.81,83.74) 25.21,84.34 v1(9.95,84.34)
BTN_1: length 84.1
  TOP w0.152: U2.90 v1(25.78,85.74) ; P2.9 47.23,59.39 47.23,59.39 47.23,59.14 46.32,58.23 45.1,58.23 43.53,59.8 41.71,59.8 39.29,62.21 v1(29.1,62.21) ; v1(9.95,85.35) 9.44,84.84 9.44,83.6 10.45,82.58 10.45,71.21 8.8,69.56 v1(8.8,67.04)
  L3_PWR w0.152: v1(8.8,67.04) 8.8,65.29 10.38,63.71 12.87,63.71 15.28,61.3 25.82,61.3 26.74,62.21 v1(29.1,62.21)
  BOTTOM w0.152: v1(25.78,85.74) 25.4,85.35 v1(9.95,85.35)
BTN_2: length 128.6
  TOP w0.152: U2.69 v1(31.36,100.09) ; P2.11 47.73,59.55 47.73,59.54 47.73,59.13 47.73,59.13 47.73,58.24 v1(48.05,57.92)
  BOTTOM w0.152: 68.37,95.51 69.76,96.91 69.76,101.99 67.1,104.66 32.17,104.66 31.36,103.84 v1(31.36,100.09) ; v1(48.05,57.92) 50.46,57.92 52.24,56.14 53.05,56.14 53.86,56.96 72.35,56.96 75.61,60.21 75.61,71.51 72.56,74.56 70.02,74.56 68.77,75.8 68.77,79.36 67.35,80.78
  BOTTOM w0.165: 68.37,95.51 68.37,85.61 67.35,84.59 67.35,80.78
BTN_3: length 52.2
  TOP w0.152: P2.13 v1(48.23,59.83) ; U2.24 v1(50.88,88.24)
  BOTTOM w0.152: v1(50.88,88.24) 53.9,88.24 54.85,89.19 61.1,89.19 61.25,89.04 61.25,78.62 55.41,72.78 55.41,70.07 55.74,69.73 55.74,68.16 55.13,67.55 49.22,67.55 48.25,66.58 48.25,59.84 v1(48.23,59.83)
BTN_4: length 88.6
  TOP w0.152: v1(8.3,66.53) 8.3,69.59 10.07,71.37 10.07,82.18 v1(8.93,83.32) ; v1(25.79,80.75) 25.87,80.75 25.88,80.74 U2.100 ; P2.15 48.73,57.84 48.33,57.44 45.35,57.44 43.37,59.42 41.58,59.42 39.32,61.68 v1(27.63,61.68)
  L3_PWR w0.152: v1(8.3,66.53) 8.3,65.01 9.95,63.36 9.95,62.32 11.32,60.94 26.13,60.94 26.86,61.68 v1(27.63,61.68)
  BOTTOM w0.152: v1(8.93,83.32) 24.35,83.32 25.79,81.88 v1(25.79,80.75)
CF1_ADC: length 117.7
  TOP w0.152: U4.6 v1(51.31,55.47) ; U2.93 22.21,84.24 19.24,87.2 19.24,90.88 17.79,92.34 11.76,92.34 10.61,91.19 3.44,91.19 v1(2.81,91.83)
  BOTTOM w0.152: v1(51.31,55.47) 51.31,55.09 50.71,54.49 47.11,54.49 45,56.6 44.67,56.6 39.56,61.71 28.79,61.71 28.26,61.17 21.53,61.17 21,60.64 3.06,60.64 1.41,62.29 1.41,90.43 v1(2.81,91.83)
CF1_ADE: length 55
  TOP w0.152: U4.23 v1(51.31,41.03) ; U1.33 v1(31.05,44.31)
  BOTTOM w0.152: v1(51.31,41.03) 51.31,41.88 51.65,42.22 52.49,42.22 53,41.72 53,39.53 51.73,38.26 39.77,38.26 38.34,39.68 32.63,39.68 32.02,40.29 32.02,43.83 31.54,44.31 v1(31.05,44.31) 23.9,44.31 TP5.1
CF2_ADC: length 116.6
  TOP w0.152: U2.92 22.25,84.74 19.62,87.36 19.62,91.04 17.95,92.72 11.6,92.72 10.71,91.83 v1(3.57,91.83) ; U4.7 v1(50.66,55.94)
  BOTTOM w0.152: v1(3.57,91.83) 1.79,90.05 1.79,62.54 3.24,61.1 20.28,61.1 21.45,62.26 27.96,62.26 28.51,62.82 29.38,62.82 30.06,62.14 39.69,62.14 44.82,57.01 45.18,57.01 47.31,54.87 50.33,54.87 50.66,55.2 v1(50.66,55.94)
CF2_ADE: length 53.3
  TOP w0.152: U1.34 v1(30.53,43.81) ; U4.22 v1(50.66,41.74)
  BOTTOM w0.152: v1(50.66,41.74) 50.66,42.09 51.25,42.68 52.77,42.68 53.43,42.02 53.43,39.33 51.98,37.88 39.51,37.88 38.09,39.3 32.4,39.3 31.64,40.06 31.64,43.57 31.4,43.81 v1(30.53,43.81) 24.87,43.81 21.38,40.32 TP47.1
CF3_ADC: length 67.8
  TOP w0.152: U5.9 v1(5.5,62.24) ; U2.71 v1(30.36,98.31)
  BOTTOM w0.152: v1(5.5,62.24) 3.47,62.24 2.5,63.2 2.5,72.4 3.09,72.98 7.86,72.98 8.75,73.87 8.75,78.44 5.22,81.97 5.22,87.08 7.03,88.88 11.62,88.88 14.22,91.48 17.59,91.47 24.42,98.31 v1(30.36,98.31)
CF3_ZX_ADE: length 54.9
  TOP w0.152: R46.2 v1(9.57,46.87) 11.8,44.64 11.8,41.33 14.01,39.12 14.01,34.43 TP7.1 ; U1.35 v1(31.03,43.31) ; 5.5,50.82 v1(5.5,49.67)
  BOTTOM w0.152: v1(9.57,46.87) 8.17,48.27 6.9,48.27 v1(5.5,49.67) ; TP7.1 14.01,34.43 22.24,34.43 23,35.19 23,40.78 25.54,43.31 v1(31.03,43.31)
CF4_ADC: length 66.8
  TOP w0.152: 6.77,60.44 v1(6.77,62.75) ; U2.72 v1(29.86,97.79)
  BOTTOM w0.152: v1(6.77,62.75) 3.7,62.75 2.94,63.51 2.94,72.12 3.44,72.63 8.01,72.63 9.15,73.76 9.15,78.56 5.6,82.1 5.6,86.83 7.28,88.5 11.88,88.5 14.49,91.12 17.74,91.12 24.41,97.79 v1(29.86,97.79)
CF4_DREADY_ADE: length 58
  TOP w0.152: TP9.1 14.26,29.6 9.57,29.6 8.68,30.49 8.68,37.19 10.78,39.3 10.78,44.38 9.95,45.22 v1(9.57,45.22) R47.2 ; U1.36 v1(30.52,42.81) ; U5.13 v1(6.77,49.67)
  BOTTOM w0.152: v1(9.57,45.22) 10.07,45.73 10.07,47.63 8.93,48.78 7.66,48.78 v1(6.77,49.67) ; v1(30.52,42.81) 26.21,42.81 23.51,40.12 23.51,34.68 22.62,33.79 18.46,33.79 TP9.1
HYP_CLK: length 29.8
  TOP w0.152: U2.65 33.36,97.37 33.4,97.42 33.4,101.44 35.73,103.77 50.71,103.77 52.09,102.4 54.27,102.4 55.24,101.42 55.24,101.04 U10.B2
HYP_CLKN: length 28.5
  TOP w0.152: U10.B1 54.83,101.04 54.83,101.26 54.1,101.99 51.92,101.99 50.55,103.36 35.9,103.36 33.81,101.27 33.81,97.42 33.86,97.37 U2.64
HYP_CS0N: length 36.4
  TOP w0.152: U10.A3 56.54,101.75 v1(56.05,102.24) ; U2.52 39.86,97.99 40.68,98.81 47.28,98.81 48.05,98.05 48.05,96.4 49.57,94.88 56.3,94.88 57.95,96.53 59.73,96.53 60.37,97.16 60.37,101.74 v1(59.86,102.24)
  BOTTOM w0.152: v1(59.86,102.24) 59.35,101.74 56.56,101.74 v1(56.05,102.24)
HYP_D0: length 33.1
  TOP w0.152: U2.53 39.36,97.18 39.44,97.27 39.44,98.21 40.43,99.2 47.54,99.2 48.43,98.31 48.43,96.53 49.7,95.26 56.17,95.26 57.83,96.91 59.35,96.91 59.86,97.42 v1(59.86,99.2) ; v1(56.05,99.2) 56.5,98.74 U10.D3
  BOTTOM w0.152: v1(59.86,99.2) 59.35,98.69 56.56,98.69 v1(56.05,99.2)
HYP_D1: length 31.6
  TOP w0.152: U2.58 36.86,100.7 37.89,101.74 46.01,101.74 49.19,98.56 49.19,96.78 49.95,96.02 55.92,96.02 57.06,97.16 57.06,97.93 56.68,98.31 55.97,98.31 U10.D2
HYP_D2: length 29.8
  TOP w0.152: v1(53.13,99.2) 51.22,101.1 47.67,101.1 46.27,102.5 36.87,102.5 34.86,100.48 U2.62 ; v1(57.06,100.21) 57.53,99.74 U10.C4
  BOTTOM w0.152: v1(57.06,100.21) 56.56,99.7 53.63,99.7 v1(53.13,99.2)
HYP_D3: length 43.7
  TOP w0.152: v1(60.87,99.2) 60.87,102.37 58.97,104.28 34.97,104.28 32.86,102.17 U2.66 ; v1(57.06,99.2) 57.52,98.74 U10.D4
  BOTTOM w0.152: v1(57.06,99.2) 57.57,99.7 60.37,99.7 v1(60.87,99.2)
HYP_D4: length 33.1
  TOP w0.152: U2.56 37.86,98.34 37.38,98.81 37.38,100.59 38.14,101.35 45.89,101.35 48.81,98.43 48.81,96.66 49.82,95.64 56.05,95.64 57.7,97.29 59.1,97.29 59.48,97.67 59.48,98.56 59.29,98.74 U10.D5
HYP_D5: length 29.5
  TOP w0.152: U10.E3 56.56,97.72 56.56,97.29 55.67,96.4 50.21,96.4 49.57,97.04 49.57,98.69 46.14,102.12 37.63,102.12 36.36,100.84 U2.59
HYP_D6: length 30.2
  TOP w0.152: v1(53.13,100.21) 51.86,101.48 47.79,101.48 46.4,102.88 36.49,102.88 34.36,100.74 U2.63 ; v1(55.03,98.18) 55.47,97.74 U10.E2
  BOTTOM w0.152: v1(53.13,100.21) 52.62,99.7 52.62,98.81 52.75,98.69 54.52,98.69 v1(55.03,98.18)
HYP_D7: length 49.3
  TOP w0.152: U10.E1 54.54,97.79 v1(54.14,98.18) ; U2.67 32.36,102.3 34.71,104.66 59.22,104.66 61.38,102.5 61.38,98.69 v1(60.87,98.18)
  BOTTOM w0.152: v1(60.87,98.18) 60.37,97.67 54.65,97.67 v1(54.14,98.18)
HYP_RESET: length 68
  TOP w0.152: v1(58.08,101.23) 57.56,101.74 U10.A4 ; v1(29.28,79.74) 28.77,79.24 U2.103 ; v1(62.4,101.23) 62.4,103.01 59.98,105.42 30.65,105.42 29.25,104.02 v1(29.25,94.24)
  BOTTOM w0.152: v1(62.4,101.23) v1(58.08,101.23) ; v1(29.28,79.74) 29.86,80.32 29.86,93.63 v1(29.25,94.24)
HYP_RWDS: length 49.1
  TOP w0.152: U2.68 31.86,102.44 34.46,105.04 59.48,105.04 61.89,102.62 v1(61.89,99.2) ; v1(56.05,100.21) 56.52,99.74 U10.C3
  BOTTOM w0.152: v1(56.05,100.21) 56.17,100.21 56.68,100.72 60.37,100.72 v1(61.89,99.2)
IAN: length 47.5
  TOP w0.152: U1.8 v1(36.6,38.76) ; R36.2 C30.2 10.72,25.02 TP43.1
  BOTTOM w0.152: TP43.1 9.82,27.57 11.6,29.35 37.38,29.35 38.9,30.87 38.9,33.41 36.6,35.72 v1(36.6,38.76)
IAP: length 52.9
  TOP w0.152: U1.7 v1(36.1,37.93) ; R35.2 C29.1 4.88,25.02 TP45.1
  BOTTOM w0.152: TP45.1 3.98,27.57 6.14,29.73 37.25,29.73 38.52,31 38.52,33.28 36.1,35.71 v1(36.1,37.93)
IBN: length 36.2
  TOP w0.152: TP25.1 22.91,25.02 C20.2 R8.2 ; U1.10 v1(37.6,38.78)
  BOTTOM w0.152: v1(37.6,38.78) 37.6,35.73 39.66,33.66 39.66,30.62 37.63,28.58 23.03,28.58 22.01,27.57 TP25.1
IBP: length 41.4
  TOP w0.152: R7.2 C19.1 17.2,25.02 TP26.1 ; U1.9 v1(37.1,38.26)
  BOTTOM w0.152: TP26.1 16.3,27.57 17.69,28.96 37.51,28.96 39.28,30.74 39.28,33.54 37.1,35.72 v1(37.1,38.26)
ICN: length 26.1
  TOP w0.152: R17.2 C25.2 35.36,25.02 TP29.1 34.46,27.57 35.98,29.09 39.03,29.09 40.43,30.49 40.43,39.81 38.93,41.31 U1.12
ICP: length 30.3
  TOP w0.152: R16.2 C24.1 29.52,25.02 TP30.1 28.62,27.57 30.65,29.6 38.65,29.6 39.92,30.87 39.92,39.58 38.69,40.81 U1.11
INN: length 26.9
  TOP w0.152: U1.14 39.32,42.31 41.44,40.19 41.44,30.74 43.09,29.09 45.25,29.09 46.78,27.57 TP39.1 47.68,25.02 C32.2 R26.2
INP: length 22.7
  TOP w0.152: U1.13 39.14,41.81 40.93,40.01 TP41.1 41.83,25.02 C31.1 R25.2
INT: length 25.7
  TOP w0.152: U2.127 38.86,73.9 38.57,73.62 v1(38.57,72.68) ; P2.34 v1(53.23,68.95)
  BOTTOM w0.152: v1(38.57,72.68) 38.57,74.35 39.79,75.57 48.58,75.57 49.98,74.18 51.35,74.18 52.24,73.29 52.24,69.95 v1(53.23,68.95)
IRQ0_ADC: length 40.8
  TOP w0.152: U2.112 v1(31.36,73.18) ; U4.4 v1(52.61,55.5) ; v1(29.05,66.61) 29.08,66.58 v1(29.08,63.36)
  BOTTOM w0.152: v1(29.05,66.61) 31.36,68.91 v1(31.36,73.18) ; v1(29.08,63.36) 29.5,63.36 30.32,62.54 39.87,62.54 45.02,57.39 50.23,57.39 52.12,55.5 v1(52.61,55.5)
IRQ0_ADE: length 74.4
  TOP w0.152: U1.31 v1(31.06,45.31) ; U4.25 52.61,41.63 v1(52.01,41.03) ; LED1.C v1(2.2,43.57)
  BOTTOM w0.152: v1(52.01,41.03) 52.01,39.81 51.22,39.02 40.27,39.02 38.78,40.52 32.98,40.52 32.78,40.73 32.78,44.34 31.81,45.31 v1(31.06,45.31) 22.92,45.31 21.05,43.44 11.34,43.44 10.45,44.33 2.96,44.33 v1(2.2,43.57) 1.59,42.96 1.59,39.1 3.98,36.71 TP10.1
IRQ1_ADC: length 64
  TOP w0.152: v1(52.62,56.78) 51.96,56.12 U4.5 ; v1(52.87,74.18) 52.9,74.15 64.02,74.15 v1(64.05,74.18) ; U2.6 v1(50.9,79.24)
  BOTTOM w0.152: v1(52.62,56.78) 53.2,57.36 67.88,57.36 73.32,62.8 73.32,70.49 71.54,72.27 69.26,72.27 67.35,74.18 v1(64.05,74.18) ; v1(52.87,74.18) 52.87,76.43 52.97,76.54 52.97,77.89 51.62,79.24 v1(50.9,79.24)
IRQ1_ADE: length 76.4
  TOP w0.152: LED6.C v1(2.2,41.92) ; U1.32 v1(30.55,44.81) ; U4.24 v1(51.96,41.74)
  BOTTOM w0.152: TP8.1 9.06,38.87 5.25,38.87 v1(2.2,41.92) 3.09,42.81 21.43,42.81 23.43,44.81 v1(30.55,44.81) 31.66,44.81 32.4,44.08 32.4,40.5 32.83,40.06 38.6,40.06 40.02,38.64 51.48,38.64 52.54,39.71 52.54,41.49 52.29,41.74 v1(51.96,41.74)
LCD_A0: length 43.6
  TOP w0.152: U2.95 25.48,83.24 25.19,82.94 22.87,82.94 22.01,82.08 22.01,79.35 25.01,76.36 25.01,71.81 26.08,70.75 27.98,70.75 29.63,69.1 37.12,69.1 37.28,69.25 v1(38.39,69.25) ; P2.10 v1(47.23,68.97)
  L3_PWR w0.152: v1(47.23,68.97) 46.64,69.55 40.07,69.55 39.77,69.25 v1(38.39,69.25)
LCD_CSB: length 13
  TOP w0.152: P2.14 48.23,68.94 v1(48.22,68.95) ; U2.135 v1(42.86,72.66)
  L3_PWR w0.152: v1(44.87,70.49) 45.89,70.49 46.45,71.05 47.89,71.05 48.22,70.72 48.22,68.95 v1(48.22,68.95)
  BOTTOM w0.152: v1(42.86,72.66) 42.86,71.62 43.98,70.49 v1(44.87,70.49)
LCD_RST: length 44.3
  TOP w0.152: v1(38.85,69.78) 37.18,69.78 36.87,69.48 29.76,69.48 28.11,71.13 26.23,71.13 25.39,71.97 25.39,76.51 22.39,79.51 22.39,81.92 23.03,82.56 25.19,82.56 25.51,82.24 U2.97 ; P2.12 47.73,68.74 47.73,68.74 47.73,69.16 47.73,69.16 v1(47.73,70.49)
  L3_PWR w0.152: v1(38.85,69.78) 39.46,69.78 39.64,69.96 47.2,69.96 v1(47.73,70.49)
LED_0: length 90.6
  TOP w0.152: P2.17 49.23,57.58 48.68,57.03 45.25,57.03 43.25,59.04 41.46,59.04 39.37,61.13 v1(29.1,61.13) ; v1(8.93,84.34) 8.32,83.73 8.32,83.15 9.69,81.78 9.69,71.53 7.79,69.62 v1(7.79,66.02) ; U2.91 v1(26.29,85.24)
  L3_PWR w0.152: v1(7.79,66.02) 7.79,64.52 8.68,63.64 8.68,62.09 10.2,60.56 26.56,60.56 27.13,61.13 v1(29.1,61.13)
  BOTTOM w0.152: v1(8.93,84.34) 9.44,84.84 25.9,84.84 v1(26.29,85.24)
LED_1: length 93.2
  TOP w0.152: v1(27.63,60.64) 39.36,60.64 41.34,58.66 43.12,58.66 45.13,56.65 48.94,56.65 49.73,57.45 P2.19 ; v1(7.28,65.52) 7.28,69.65 9.31,71.68 9.31,81.62 7.89,83.04 7.89,84.06 v1(8.17,84.34) ; U2.96 v1(25.82,82.74)
  L3_PWR w0.152: v1(7.28,65.52) 7.28,62.42 9.51,60.18 27.17,60.18 v1(27.63,60.64)
  BOTTOM w0.152: v1(8.17,84.34) 8.68,83.83 24.73,83.83 v1(25.82,82.74)
LINK_ST: length 20.5
  TOP w0.152: P2.40 v1(54.73,69.48) ; v1(49.82,72.27) 53.25,72.27 53.76,71.76 v1(54.4,71.76) ; U2.139 v1(44.86,72.69)
  BOTTOM w0.152: v1(44.86,72.69) 44.08,72.69 43.86,72.91 43.86,73.8 44.11,74.05 48.05,74.05 v1(49.82,72.27) ; v1(54.73,69.48) 54.73,69.62 54.65,69.71 54.65,70.75 54.4,71 v1(54.4,71.76)
MISO_ADC: length 35
  TOP w0.152: U2.117 v1(33.86,72.66) ; U5.5 v1(10.58,62.75)
  BOTTOM w0.152: v1(33.86,72.66) 34.41,72.1 34.41,68.96 29.72,64.27 12.54,64.27 11.72,63.46 10.81,63.46 10.58,63.23 v1(10.58,62.75)
MISO_ADE: length 60.4
  TOP w0.152: U1.38 v1(30.54,41.81) 29.82,42.53 29.48,42.53 29.25,42.76 R96.1 22.01,43.36 18.62,46.74 13.25,46.74 10.58,49.41 10.58,50.82
  BOTTOM w0.152: TP3.1 7.66,30.11 22.52,30.11 24.53,32.11 24.53,38.72 27.62,41.81 v1(30.54,41.81)
MOSI_ADC: length 34.2
  TOP w0.152: U2.118 v1(34.36,73.17) ; 11.85,60.44 v1(11.85,62.75)
  BOTTOM w0.152: v1(11.85,62.75) 11.85,63.05 12.69,63.89 29.88,63.89 34.91,68.92 34.91,72.61 v1(34.36,73.17)
MOSI_ADE: length 33.7
  TOP w0.152: U5.17 v1(11.85,49.67) ; TP2.1 23.41,39.76 21.25,39.76 16.8,44.2 v1(13.76,44.2) ; U1.39 v1(31.06,41.31)
  BOTTOM w0.152: v1(13.76,44.2) 13.76,49.79 13.38,50.17 12.36,50.17 v1(11.85,49.67) ; v1(31.06,41.31) 29.25,41.31 26.46,38.52 TP2.1
NR_D_485: length 17.9
  TOP w0.152: P2.5 v1(46.23,59.67) ; U2.144 v1(47.36,73.18)
  BOTTOM w0.152: v1(46.23,59.67) 47.16,60.6 47.16,67.95 47.71,68.51 47.71,69.52 48.21,70.02 48.21,70.84 47.36,71.69 v1(47.36,73.18)
PM1_ADE: length 10
  TOP w0.152: R81.2 v1(35.09,36.71) 35.1,36.72 U1.5
  BOTTOM w0.152: TP49.1 35.1,34.56 35.1,36.71 v1(35.09,36.71)
PPS_RTC: length 37.5
  TOP w0.152: R60.2 R59.2 R62.2 18.84,66.56 19.85,67.57 27.6,67.57 27.98,67.19 39.79,67.19 43.6,71 v1(45.36,71) ; U2.140 v1(45.36,73.19)
  BOTTOM w0.152: v1(45.36,71) v1(45.36,73.19)
REF: length 2.7
  TOP w0.152: U1.16 40.04,43.31 40.3,43.05 FB1.2
RESET_ADC: length 37
  TOP w0.152: U2.116 v1(33.36,73.21) ; U5.7 v1(8.04,62.75)
  BOTTOM w0.152: v1(8.04,62.75) 8.04,63.18 8.73,63.86 11.6,63.86 12.39,64.65 29.56,64.65 33.91,69 33.91,71.9 33.37,72.44 33.37,73.19 v1(33.36,73.21)
RESET_ADE: length 50.5
  TOP w0.152: R43.1 29.3,35.48 C39.1 v1(29.25,34.3) 28.51,34.3 27.96,34.86 27.96,37.37 24.55,40.78 21.76,40.78 17.31,45.22 12.56,45.22 9.24,48.55 8.47,48.55 8.04,48.98 8.04,50.82 ; U1.6 v1(35.6,38.44)
  BOTTOM w0.152: TP6.1 35.6,32.91 v1(35.6,38.44) 35.09,38.44 32.86,36.2 31.16,36.2 v1(29.25,34.3)
RSTN: length 58.7
  TOP w0.152: S1.1 12.7,80.13 13.05,80.49 C180.2 12.36,81.16 11.85,81.67 v1(11.85,82.3) P1.10 11.85,85.62 10.97,86.5 R125.2 ; U2.114 v1(32.36,73.19)
  BOTTOM w0.152: v1(32.36,73.19) 32.36,68.59 29.43,65.67 27.6,65.67 26.58,66.68 12.41,66.68 11.57,67.52 11.57,75.42 12.23,76.08 13.88,76.08 14.65,76.84 14.65,81.16 13.76,82.05 13.76,82.56 13.5,82.81 12.36,82.81 v1(11.85,82.3)
RTC_32K: length 16.8
  TOP w0.152: U2.107 v1(29.1,77.24) ; R58.2 v1(16.8,72.53)
  BOTTOM w0.152: v1(16.8,72.53) 16.8,73.29 20.75,77.24 v1(29.1,77.24)
RTC_SCL: length 59.1
  TOP w0.152: R57.2 12.91,74.78 v1(12.91,74.3) U3.8 ; v1(48.81,76.08) 48.05,75.32 48.05,72.78 47.41,72.14 43.73,72.14 39.54,67.95 29,67.95 v1(27.6,69.35) ; U2.20 50.39,86.24 50.49,86.14 v1(50.89,86.14)
  BOTTOM w0.152: v1(50.89,86.14) 49.37,84.62 49.37,76.64 v1(48.81,76.08) ; v1(27.6,69.35) 27.35,69.1 23.69,69.1 21.53,71.26 16.45,71.26 14.14,73.57 14.14,74.41 13.99,74.56 13.16,74.56 v1(12.91,74.3)
RTC_SDA: length 59.3
  TOP w0.152: U3.7 v1(13.56,73.92) 13.56,74.75 R61.2 ; v1(49.57,76.08) 48.43,74.94 48.43,72.4 47.79,71.76 43.86,71.76 39.66,67.57 28.49,67.57 v1(27.6,68.46) ; U2.19 50.33,85.74 50.41,85.66 51.27,85.66 v1(51.58,85.96)
  BOTTOM w0.152: v1(49.57,76.08) 49.82,76.34 49.82,84.21 v1(51.58,85.96) ; v1(27.6,68.46) 27.35,68.72 23.54,68.72 21.38,70.87 16.27,70.87 13.56,73.59 v1(13.56,73.92)
RXD_485: length 17.6
  TOP w0.152: U2.143 v1(46.86,72.66) ; P2.1 v1(45.23,59.67)
  BOTTOM w0.152: v1(45.23,59.67) 45.23,67.04 46.75,68.56 46.75,69.57 47.21,70.04 47.21,71.08 46.86,71.43 v1(46.86,72.66)
RXEV: length 76.2
  TOP w0.152: P2.54 58.24,70.52 59.93,72.22 62.27,72.22 65.22,69.27 66.64,69.27 68.11,70.75 68.11,79.13 66.97,80.27 66.97,85.86 68.62,87.51 68.62,99.07 v1(67.1,100.59) ; U2.40 v1(45.86,98.3)
  BOTTOM w0.152: v1(45.86,98.3) 45.86,98.78 46.27,99.2 47.72,99.2 51.09,95.82 64.1,95.82 65.07,96.78 65.57,96.78 66.59,97.8 66.59,100.08 v1(67.1,100.59)
SCL_0: length 26.8
  TOP w0.152: R53.2 40.83,63.34 v1(40.83,63.33) ; U2.130 v1(40.36,73.19) ; P2.21 v1(50.23,59.34)
  BOTTOM w0.152: v1(50.23,59.34) 49.7,58.81 47.67,58.81 47.03,58.17 45.25,58.17 40.83,62.59 v1(40.83,63.33) 40.83,71.84 40.37,72.3 40.37,73.18 v1(40.36,73.19)
SCLK_ADC: length 43.7
  TOP w0.152: v1(12.59,62.75) 12.59,61.96 13.12,61.43 U5.3 ; U2.115 v1(32.86,72.69)
  BOTTOM w0.152: v1(32.86,72.69) 32.86,72.35 33.41,71.79 33.41,69.04 29.4,65.03 12.21,65.03 11.45,64.27 8.52,64.27 7.41,63.15 7.41,62.52 7.66,62.26 8.35,62.26 9.01,62.92 9.62,62.92 10.4,62.14 11.98,62.14 v1(12.59,62.75)
SCLK_ADE: length 42
  TOP w0.152: TP1.1 18.58,34.43 18.58,39.25 16.04,41.79 14.39,41.79 12.99,43.19 v1(12.99,44.2) ; 13.12,50.82 v1(13.12,49.67) ; U1.37 v1(31.04,42.31)
  BOTTOM w0.152: v1(31.04,42.31) 26.98,42.31 24.02,39.35 24.02,34.27 TP1.1 ; v1(12.99,44.2) 13.07,44.28 13.07,49.62 v1(13.12,49.67)
SDA_0: length 40.4
  TOP w0.152: R55.2 v1(61.89,59.06) ; U2.129 v1(39.86,72.68) ; P2.23 v1(50.73,58.83)
  BOTTOM w0.152: v1(39.86,72.68) 39.86,72.11 40.35,71.61 40.35,62.57 45.13,57.79 47.18,57.79 47.82,58.43 50.33,58.43 v1(50.73,58.83) 51.64,57.92 60.75,57.92 v1(61.89,59.06)
SDIO_CD: length 112.9
  TOP w0.152: v1(72.56,58.81) 72.56,59.44 71.92,60.08 67.51,60.08 65.35,57.92 58.21,57.92 57.74,58.39 P2.51 ; U2.61 v1(35.36,97.75)
  BOTTOM w0.152: 67.99,95.77 69.38,97.16 69.38,101.86 66.97,104.28 35.98,104.28 35.36,103.65 v1(35.36,97.75) ; 66.97,80.53 68.37,79.13 68.37,75.7 69.89,74.18 72.4,74.18 75.22,71.35 75.22,60.71 73.32,58.81 v1(72.56,58.81)
  BOTTOM w0.165: 66.97,80.53 66.97,84.84 67.99,85.86 67.99,95.77
SDIO_CLK: length 103.2
  TOP w0.152: v1(73.19,59.57) 72.3,60.46 67.35,60.46 65.19,58.3 58.59,58.3 58.54,58.35 58.54,58.35 58.25,58.63 58.25,58.63 58.24,58.65 P2.53 ; U2.51 v1(40.36,97.78)
  BOTTOM w0.152: 67.62,95.91 67.62,95.92 69,97.3 69,101.74 66.84,103.89 43.35,103.89 40.36,100.9 v1(40.36,97.78) ; 66.59,80.27 67.99,78.88 67.99,75.57 69.76,73.8 72.24,73.8 74.84,71.19 74.84,61.22 v1(73.19,59.57)
  BOTTOM w0.165: 67.62,95.91 67.62,86.13 66.59,85.1 66.59,80.27
SDIO_CMD: length 101.4
  TOP w0.152: v1(65.45,95.13) 65.7,94.88 65.7,89.43 65.55,89.28 64.07,89.28 63.92,89.13 63.92,88.82 64.07,88.67 65.55,88.67 65.7,88.52 65.7,88.21 65.55,88.06 64.07,88.06 63.92,87.91 63.92,87.6 64.07,87.45 65.55,87.45 65.7,87.3 65.7,86.99 65.55,86.84 64.07,86.84 63.92,86.69 63.92,86.38 64.07,86.23 65.55,86.23 65.7,86.08 65.7,85.77 65.55,85.62 64.07,85.62 63.92,85.47 63.92,85.16 64.07,85.01 65.55,85.01 65.7,84.86 65.7,84.56 65.55,84.4 64.07,84.4 63.92,84.25 63.92,83.95 64.07,83.79 65.55,83.79 65.7,83.64 65.7,83.34 65.55,83.18 64.07,83.18 63.92,83.03 63.92,82.73 64.07,82.57 65.55,82.57 65.7,82.42 65.7,82.12 65.55,81.96 64.07,81.96 63.92,81.81 63.92,81.51 64.07,81.35 65.55,81.35 65.7,81.2 65.7,80.9 65.55,80.75 64.07,80.75 63.92,80.59 63.92,80.29 64.07,80.14 65.55,80.14 65.7,79.98 65.7,79.68 65.55,79.53 64.07,79.53 63.92,79.37 63.92,79.07 64.07,78.92 65.55,78.92 65.7,78.76 65.7,78.46 65.55,78.31 64.07,78.31 63.92,78.15 63.92,77.85 64.07,77.7 65.55,77.7 65.7,77.54 65.7,73.16 v1(66.21,72.65) ; U2.37 v1(47.36,97.45) ; P2.55 v1(58.74,58.83)
  BOTTOM w0.152: v1(66.21,72.65) 66.97,72.65 67.93,71.69 67.93,61.81 65.7,59.57 61.51,59.57 60.24,58.3 59.27,58.3 v1(58.74,58.83) ; v1(47.36,97.45) 47.36,97.44 47.87,97.44 50.56,94.75 60.95,94.75 61.79,93.91 64.23,93.91 v1(65.45,95.13)
SDIO_DAT0: length 101.8
  TOP w0.152: v1(64.68,98.05) 64.3,97.67 64.3,95.89 60.87,92.46 60.87,91.94 61.03,91.78 62.25,91.78 62.4,91.63 62.4,91.33 62.25,91.17 61.03,91.17 60.87,91.02 60.87,90.72 61.03,90.56 62.25,90.56 62.4,90.41 62.4,90.11 62.25,89.95 61.03,89.95 60.87,89.8 60.87,89.5 61.03,89.35 62.25,89.35 62.4,89.19 62.4,88.89 62.25,88.74 61.03,88.74 60.87,88.58 60.87,88.28 61.03,88.13 62.25,88.13 62.4,87.97 62.4,87.67 62.25,87.52 61.03,87.52 60.87,87.36 60.87,87.06 61.03,86.91 62.25,86.91 62.4,86.75 62.4,86.45 62.25,86.3 61.03,86.3 60.87,86.14 60.87,85.84 61.03,85.69 62.25,85.69 62.4,85.54 62.4,85.23 62.25,85.08 61.03,85.08 60.87,84.93 60.87,84.62 61.03,84.47 62.25,84.47 62.4,84.32 62.4,84.01 62.25,83.86 61.03,83.86 60.87,83.71 60.87,76.46 61.38,75.95 63.46,75.95 64.89,74.52 64.89,71.56 v1(66.21,70.24) ; P2.43 v1(55.74,58.81) ; U2.45 v1(43.36,97.75)
  BOTTOM w0.152: v1(43.36,97.75) 43.36,98.82 44.87,100.34 49.32,100.34 52.72,96.94 63.57,96.94 v1(64.68,98.05) ; v1(66.21,70.24) 66.56,70.24 66.72,70.09 66.72,62.49 64.94,60.71 56.68,60.71 55.74,59.77 v1(55.74,58.81)
SDIO_DAT1: length 101.4
  TOP w0.152: v1(71.67,59.57) 67.54,59.57 65.51,57.54 57.14,57.54 56.24,58.44 56.24,61.27 P2.45 ; U2.49 v1(41.36,97.76)
  BOTTOM w0.152: v1(41.36,97.76) 41.36,100.89 43.6,103.13 66.59,103.13 68.24,101.48 68.24,97.67 66.84,96.27 ; 65.81,79.78 67.21,78.38 67.21,75.33 69.5,73.05 71.93,73.05 74.09,70.88 74.09,62 v1(71.67,59.57)
  BOTTOM w0.165: 66.84,96.27 66.84,86.62 65.81,85.59 65.81,79.78
SDIO_DAT2: length 102.7
  TOP w0.152: v1(67.1,99.83) 66.41,99.15 66.41,98.69 66.56,98.54 67.71,98.54 67.86,98.38 67.86,98.08 67.71,97.93 66.56,97.93 66.41,97.77 66.41,97.47 66.56,97.32 67.71,97.32 67.86,97.16 67.86,96.86 67.71,96.71 66.56,96.71 66.41,96.55 66.41,96.25 66.56,96.1 67.71,96.1 67.86,95.94 67.86,95.64 67.71,95.49 66.56,95.49 66.41,95.34 66.41,95.03 66.56,94.88 67.71,94.88 67.86,94.73 67.86,94.42 67.71,94.27 66.56,94.27 66.41,94.12 66.41,93.81 66.56,93.66 67.71,93.66 67.86,93.51 67.86,93.2 67.71,93.05 66.56,93.05 66.41,92.9 66.41,92.59 66.56,92.44 67.71,92.44 67.86,92.29 67.86,91.98 67.71,91.83 66.56,91.83 66.41,91.68 66.41,91.37 66.56,91.22 67.71,91.22 67.86,91.07 67.86,90.76 67.71,90.61 66.56,90.61 66.41,90.46 66.41,90.15 66.56,90 67.71,90 67.86,89.85 67.86,89.54 67.71,89.39 66.56,89.39 66.41,89.24 66.41,74.86 67.2,74.08 67.2,71.48 66.66,70.95 v1(66.21,70.95) ; U2.39 v1(46.36,97.8) ; P2.47 56.74,58.81 v1(56.74,58.81)
  BOTTOM w0.152: v1(66.21,70.95) 66.61,70.95 67.1,70.47 67.1,62.37 65.06,60.33 57.32,60.33 56.74,59.76 v1(56.74,58.81) ; v1(67.1,99.83) 67.1,97.8 65.7,96.4 65.19,96.4 63.49,94.7 62.07,94.7 61.31,95.46 50.95,95.46 47.59,98.81 46.65,98.81 46.36,98.52 v1(46.36,97.8)
SDIO_DAT3: length 101
  TOP w0.152: P2.49 v1(57.24,59.36) ; v1(65.45,98.05) 64.68,97.29 64.68,95.13 63.16,93.61 63.16,93.1 63.31,92.94 64.15,92.94 64.3,92.79 64.3,92.49 64.15,92.33 63.31,92.33 63.16,92.18 63.16,91.88 63.31,91.72 64.15,91.72 64.3,91.57 64.3,91.27 64.15,91.11 63.31,91.11 63.16,90.96 63.16,90.66 63.31,90.5 64.15,90.5 64.3,90.35 64.3,90.05 64.15,89.89 63.31,89.89 63.16,89.74 63.16,83.17 63.01,83.02 61.53,83.02 61.38,82.87 61.38,82.56 61.53,82.41 63.01,82.41 63.16,82.26 63.16,81.95 63.01,81.8 61.53,81.8 61.38,81.65 61.38,81.35 61.53,81.19 63.01,81.19 63.16,81.04 63.16,80.74 63.01,80.58 61.53,80.58 61.38,80.43 61.38,80.13 61.53,79.97 63.01,79.97 63.16,79.82 63.16,79.52 63.01,79.36 61.53,79.36 61.38,79.21 61.38,78.91 61.53,78.75 63.01,78.75 63.16,78.6 63.16,78.3 63.01,78.14 61.53,78.14 61.38,77.99 61.38,77.69 61.53,77.54 63.01,77.54 65.32,75.22 65.32,72.65 v1(66.21,71.76) ; U2.43 v1(44.36,97.77)
  BOTTOM w0.152: v1(66.21,71.76) 66.97,71.76 67.58,71.15 67.58,62.21 65.32,59.95 57.44,59.95 57.24,59.74 v1(57.24,59.36) ; v1(65.45,98.05) 64.94,97.54 64.69,97.54 63.7,96.55 52.47,96.55 49.06,99.96 45,99.96 44.36,99.31 v1(44.36,97.77)
SHIELD: length 11.8
  TOP w0.635: P10.GND1 6.41,102.19 5.25,101.02 5.25,94.75 6.45,93.55 P10.GND2
SPI0_MISO: length 12.3
  TOP w0.152: P2.16 v1(48.73,70.45) ; U2.138 v1(44.36,73.2)
  BOTTOM w0.152: v1(44.36,73.2) 44.82,73.67 47.92,73.67 48.73,72.86 v1(48.73,70.45)
SPI0_MOSI: length 7.9
  TOP w0.152: U2.141 v1(45.86,72.67) ; P2.6 v1(46.23,68.93)
  BOTTOM w0.152: v1(45.86,72.67) 45.86,71.16 46.23,70.79 v1(46.23,68.93)
SPI0_SCK: length 7.9
  TOP w0.152: U2.142 v1(46.36,73.17) ; P2.8 v1(46.73,70.49)
  BOTTOM w0.152: v1(46.36,73.17) 46.36,71.42 46.73,71.05 v1(46.73,70.49)
SPI0_SS0: length 25.4
  TOP w0.152: P2.18 v1(49.23,68.93) ; v1(50.87,81.49) 50.61,81.24 U2.10
  BOTTOM w0.152: v1(50.87,81.49) 50.87,81.44 51.07,81.24 52.54,81.24 53,80.78 54.14,80.78 54.65,80.27 54.65,73.54 54.27,73.16 53.89,73.16 53.25,72.52 53.25,69.99 53.75,69.49 53.75,68.58 53.51,68.33 49.82,68.33 v1(49.23,68.93)
SPI2_MISO__SPI_CFG1: length 33.2
  TOP w0.152: P2.32 v1(52.73,70.48) ; U2.123 v1(36.86,72.69)
  L3_PWR w0.152: v1(35.85,65.16) 36.31,65.16 36.54,65.39 43.83,65.39 45.25,66.81 50.2,66.81 51.73,68.33 51.73,69.48 v1(52.73,70.48)
  BOTTOM w0.152: v1(36.86,72.69) 36.86,66.16 v1(35.85,65.16)
SPI2_MOSI: length 31.6
  TOP w0.152: U2.124 v1(37.36,73.19) ; P2.30 v1(52.23,68.96)
  L3_PWR w0.152: v1(52.23,68.96) 52.23,68.2 50.36,66.33 45.59,66.33 44.29,65.03 37.12,65.03 36.49,64.4 v1(35.85,64.4)
  BOTTOM w0.152: v1(37.36,73.19) 37.36,65.9 v1(35.85,64.4)
SPI2_SCK: length 31.6
  TOP w0.152: P2.28 v1(51.73,70.49) ; U2.122 v1(36.36,73.2)
  L3_PWR w0.152: v1(35.85,65.92) 37.96,65.92 40.78,68.74 43.32,68.74 44.26,67.8 49.93,67.8 50.74,68.61 50.74,69.5 v1(51.73,70.49)
  BOTTOM w0.152: v1(36.36,73.2) 36.36,66.42 v1(35.85,65.92)
SPI2_SS0: length 25.3
  TOP w0.152: U2.125 v1(37.86,72.67) ; P2.26 v1(51.23,68.96)
  L3_PWR w0.152: v1(51.23,68.96) 51.23,68.47 50.05,67.29 44.08,67.29 43.04,68.33 41.47,68.33 v1(39.5,66.37)
  BOTTOM w0.152: v1(39.5,66.37) 39.87,66.73 39.87,70.66 v1(37.86,72.67)
SPI3_MISO: length 61.9
  TOP w0.152: U2.35 49.37,93.76 v1(51.55,93.76) ; P2.29 v1(52.23,59.32)
  BOTTOM w0.152: v1(51.55,93.76) 60.9,93.76 64.25,90.41 64.3,90.36 64.3,77.61 62.78,76.08 62.78,70.27 64.81,68.23 64.81,63.64 63.79,62.62 53.74,62.62 52.23,61.12 v1(52.23,59.32)
SPI3_MOSI: length 63.5
  TOP w0.152: P2.31 v1(52.73,58.82) ; v1(50.94,94.27) 50.91,94.24 U2.36
  BOTTOM w0.152: v1(52.73,58.82) 52.73,60.96 54.02,62.24 63.92,62.24 65.19,63.51 65.19,68.49 63.16,70.52 63.16,75.95 64.68,77.48 64.68,90.48 60.9,94.27 v1(50.94,94.27)
SPI3_SCK: length 66.8
  TOP w0.152: v1(50.87,91.02) 50.65,91.24 U2.30 ; P2.25 v1(51.23,59.33)
  BOTTOM w0.152: v1(51.23,59.33) 51.23,61.39 53.23,63.38 63.54,63.38 64.05,63.89 64.05,67.57 63.29,68.33 57.98,68.33 57.44,68.87 57.44,70.95 56.84,71.56 56.84,72.17 62.78,78.11 62.78,89.8 61.23,91.35 53.96,91.35 53.38,90.76 52.11,90.76 51.86,91.02 v1(50.87,91.02)
SPI3_SDIO2: length 40.3
  TOP w0.152: v1(51.4,91.5) 50.97,91.5 50.73,91.74 U2.31 ; v1(57.32,71.76) 57.32,70.54 57.24,70.46 P2.50
  BOTTOM w0.152: v1(51.4,91.5) 51.93,91.5 52.39,91.96 61.16,91.96 63.16,89.96 63.16,77.99 57.32,72.14 v1(57.32,71.76)
SPI3_SDIO3: length 39.1
  TOP w0.152: P2.48 v1(56.74,70.87) ; U2.28 v1(50.87,90.24)
  BOTTOM w0.152: v1(56.74,70.87) 56.48,71.13 56.48,72.32 62.4,78.24 62.4,89.64 61.04,90.99 54.24,90.99 53.49,90.24 v1(50.87,90.24)
SPI3_SS0: length 41.6
  TOP w0.152: v1(50.92,93.28) 49.39,93.28 U2.34 ; P2.52 57.74,70.71 58.33,71.31 v1(58.33,71.76)
  BOTTOM w0.152: v1(50.92,93.28) 60.88,93.28 63.9,90.26 63.9,77.71 58.33,72.14 v1(58.33,71.76)
SPI3_SS1: length 37.6
  TOP w0.152: P2.44 55.74,69.62 55.92,69.81 v1(55.92,70.24) ; U2.25 v1(51.38,88.74)
  BOTTOM w0.152: v1(55.92,70.24) 55.92,70.34 55.77,70.49 55.77,72.63 61.64,78.49 61.64,89.32 61.39,89.57 54.55,89.57 53.72,88.74 v1(51.38,88.74)
SPI3_SS2: length 38.8
  TOP w0.152: v1(50.9,89.24) 50.89,89.24 U2.26 ; v1(56.23,68.85) 56.23,68.79 56.24,68.78 P2.46
  BOTTOM w0.152: v1(50.9,89.24) 53.13,89.24 54.5,90.61 60.89,90.61 62.02,89.48 62.02,78.37 56.12,72.48 56.12,70.8 56.43,70.49 56.43,69.06 v1(56.23,68.85)
SPI3_SS3: length 68.2
  TOP w0.152: P2.27 v1(51.73,58.81) ; U2.32 50.59,92.24 50.69,92.13 v1(51.09,92.13)
  BOTTOM w0.152: v1(51.73,58.81) 51.73,61.25 53.48,63 63.67,63 64.43,63.76 64.43,67.83 63.54,68.72 58.69,68.72 58.21,69.2 58.21,71.13 57.83,71.51 57.83,72.14 63.54,77.86 63.54,90.11 61.34,92.31 52.19,92.31 52.01,92.13 v1(51.09,92.13)
SPI_CFG1: length 36.3
  TOP w0.152: P2.36 v1(53.73,70.47) ; U2.120 v1(35.36,73.22)
  L3_PWR w0.152: v1(53.73,70.47) 52.74,69.47 52.74,68.07 50.54,65.87 45.96,65.87 44.77,64.68 37.71,64.68 36.67,63.64 v1(35.85,63.64)
  BOTTOM w0.152: v1(35.85,63.64) 35.36,64.14 v1(35.36,73.22)
SPIXF_SCK: length 28.5
  TOP w0.152: U2.13 51.35,82.74 v1(51.55,82.94) ; U11.6 v1(57.78,88.71)
  BOTTOM w0.152: v1(51.55,82.94) 53.98,82.94 55.75,81.17 55.75,78.5 56.26,77.99 59.56,77.99 60.83,79.26 60.83,87.05 59.17,88.71 v1(57.78,88.71)
SPIXF_SDIO0: length 12.2
  TOP w0.152: v1(51.58,84.49) 51.33,84.74 U2.17 ; U11.5 v1(59.05,85.4)
  BOTTOM w0.152: v1(51.58,84.49) 58.14,84.49 v1(59.05,85.4)
SPIXF_SDIO1: length 12.3
  TOP w0.152: U11.2 v1(56.51,78.63) ; U2.15 v1(51.56,83.74)
  BOTTOM w0.152: v1(56.51,78.63) 56.51,81.04 54.16,83.4 51.9,83.4 v1(51.56,83.74)
SPIXF_SDIO2: length 21
  TOP w0.152: U11.3 v1(57.78,78.63) ; U2.22 v1(50.89,87.24)
  BOTTOM w0.152: v1(57.78,78.63) 57.78,83.13 59.73,85.07 59.73,86.5 58.99,87.24 v1(50.89,87.24)
SPIXF_SDIO3: length 8.8
  TOP w0.152: U11.7 v1(56.51,88.71) ; U2.23 v1(51.4,87.74)
  BOTTOM w0.152: v1(51.4,87.74) 55.54,87.74 v1(56.51,88.71)
SPIXF_SS0: length 10.6
  TOP w0.152: U11.1 v1(55.24,78.63) ; U2.12 v1(50.87,82.24)
  BOTTOM w0.152: v1(50.87,82.24) 51.43,82.24 51.63,82.43 53.85,82.43 55.24,81.04 v1(55.24,78.63)
SPIXR_SCK: length 17.6
  TOP w0.152: v1(50.33,74.68) 48.81,73.16 48.81,72.14 48.05,71.38 46.4,71.38 45.79,70.77 45.79,70.37 45.23,69.81 P2.2 ; U2.4 50.21,78.24 50.71,77.73 v1(51.83,77.73)
  BOTTOM w0.152: v1(51.83,77.73) 51.83,77.63 51.98,77.48 51.98,75.7 50.97,74.68 v1(50.33,74.68)
SPIXR_SDIO0: length 15.9
  TOP w0.152: P2.4 45.73,69.7 46.25,70.22 46.25,70.69 46.55,71 48.3,71 49.19,71.89 49.19,72.53 50.84,74.18 50.84,75.23 50.69,75.38 v1(50.33,75.38) ; U2.2 v1(50.92,77.24)
  BOTTOM w0.152: v1(50.92,77.24) 50.92,75.54 50.77,75.38 v1(50.33,75.38)
SPIXR_SDIO1: length 26.7
  TOP w0.152: U2.7 v1(51.4,79.74) ; v1(62.27,74.81) v1(53.38,74.81) ; P2.58 v1(59.24,69.25)
  BOTTOM w0.152: v1(59.24,69.25) 59.25,69.25 59.83,69.83 60.95,69.83 62.27,71.15 v1(62.27,74.81) ; v1(53.38,74.81) 53.38,77.99 52.75,78.62 52.75,78.88 51.89,79.74 v1(51.4,79.74)
SS_ADC: length 74.6
  TOP w0.152: 9.31,60.44 v1(9.31,62.42) ; U2.70 v1(30.86,97.8)
  BOTTOM w0.152: v1(9.31,62.42) 8.42,61.53 3.47,61.53 2.15,62.85 2.15,72.63 2.89,73.36 7.74,73.36 8.37,73.99 8.37,78.32 4.84,81.85 4.84,87.33 6.77,89.26 11.37,89.26 13.99,91.88 17.48,91.88 24.42,98.82 30.6,98.82 30.86,98.57 v1(30.86,97.8)
SS_ADE: length 39.4
  TOP w0.152: U1.40 v1(30.56,40.81) 30.23,40.81 29.29,41.75 R54.1 22.27,41.75 18.04,45.98 12.87,45.98 9.31,49.54 U5.15
  BOTTOM w0.152: TP4.1 27.96,33.13 27.96,39.23 29.54,40.81 v1(30.56,40.81)
SWPD_EN: length 18.4
  TOP w0.152: U2.133 v1(41.86,72.71) ; P2.20 v1(49.73,70.46)
  BOTTOM w0.152: v1(41.86,72.71) 41.86,73.57 42.71,74.43 48.17,74.43 49.7,72.91 50.08,72.91 50.33,72.65 50.33,71.51 49.73,70.91 v1(49.73,70.46)
TCK: length 44.6
  TOP w0.152: v1(30.09,73.19) 30.09,73.57 30.36,73.83 U2.110 ; P1.4 v1(15.66,82.3)
  BOTTOM w0.152: v1(15.66,82.3) 15.66,81.16 15.41,80.91 15.41,76.21 14.52,75.32 12.87,75.32 12.33,74.79 12.33,67.85 12.74,67.45 29.25,67.45 30.95,69.15 30.95,72.32 v1(30.09,73.19)
TMS: length 49.7
  TOP w0.152: P1.2 v1(16.93,82.3) ; U2.113 v1(31.86,72.15)
  BOTTOM w0.152: v1(16.93,82.3) 16.93,82.66 16.78,82.81 15.18,82.81 15.03,82.66 15.03,76.46 14.26,75.7 12.61,75.7 11.95,75.04 11.95,67.67 12.59,67.04 26.73,67.04 27.72,66.05 29.28,66.05 31.86,68.63 v1(31.86,72.15)
TS_CAPT: length 25.4
  TOP w0.152: v1(50.33,76.08) 53.76,76.08 54.4,76.72 v1(55.29,76.72) ; P2.42 v1(55.23,68.92) ; U2.16 v1(50.9,84.24)
  BOTTOM w0.152: v1(50.33,76.08) 50.33,83.66 v1(50.9,84.24) ; v1(55.29,76.72) 55.67,76.34 55.67,73.54 55.03,72.91 55.03,69.94 55.23,69.74 v1(55.23,68.92)
TS_TIMER__MS_SEL: length 24.2
  TOP w0.152: v1(51.22,73.54) 53,73.54 v1(54.02,72.53) ; P2.38 v1(54.23,68.93) ; U2.131 v1(40.86,72.7)
  BOTTOM w0.152: v1(54.02,72.53) 53.76,72.27 53.76,71.13 54.23,70.66 v1(54.23,68.93) ; v1(51.22,73.54) 50.97,73.8 49.82,73.8 48.43,75.19 41.57,75.19 40.86,74.48 v1(40.86,72.7)
TX2P4_EN: length 21.4
  TOP w0.152: P2.22 v1(50.23,68.94) ; U2.134 42.36,73.2 v1(42.36,73.2)
  BOTTOM w0.152: v1(42.36,73.2) 42.36,72.53 42.06,72.23 41.66,72.23 41.37,72.51 41.37,73.85 42.33,74.81 48.3,74.81 49.82,73.29 50.33,73.29 50.71,72.91 50.71,71.26 50.23,70.77 v1(50.23,68.94)
TXD_485: length 28.2
  TOP w0.152: v1(52.75,71.76) 52.49,71.51 v1(49.57,71.51) ; P2.3 v1(45.73,59.17) ; U2.1 v1(52.49,76.74)
  BOTTOM w0.152: v1(45.73,59.17) 46.47,59.17 47.67,60.36 47.67,67.45 48.7,68.48 48.7,69.5 49.21,70.01 49.21,71.15 v1(49.57,71.51) ; v1(52.49,76.74) 52.49,75.19 52.24,74.94 52.24,73.92 52.75,73.41 v1(52.75,71.76)
TXEV: length 78.2
  TOP w0.152: U2.41 v1(45.36,97.79) ; v1(67.1,101.35) 69,99.45 69,87.36 67.35,85.71 67.35,80.39 68.47,79.28 68.47,70.6 66.79,68.92 65.06,68.92 62.17,71.81 60.11,71.81 58.74,70.44 P2.56
  BOTTOM w0.152: v1(67.1,101.35) 66.21,100.47 66.21,97.93 65.45,97.16 64.81,97.16 63.82,96.17 51.27,96.17 47.87,99.58 45.76,99.58 45.36,99.17 v1(45.36,97.79)
UART0_RX: length 48
  TOP w0.152: U2.132 41.36,73.21 41.36,73.21 41.36,70.79 39.28,68.72 29.5,68.72 27.85,70.37 25.92,70.37 24.65,71.64 24.65,76.21 21.61,79.26 21.61,84.18 18.99,86.8 13.73,86.8 13.12,86.19 P1.8
UART0_TX: length 47.9
  TOP w0.152: P1.6 14.39,86.11 14.65,86.37 18.79,86.37 21.22,83.93 21.22,79.13 24.26,76.1 24.26,71.52 25.8,69.99 27.73,69.99 29.38,68.33 39.41,68.33 43.22,72.14 43.22,72.14 43.86,72.78 U2.137
UART2_CTS: length 75.8
  TOP w0.152: v1(66.46,73.67) 66.06,74.08 66.06,95.28 v1(65.45,95.89) ; U2.38 v1(46.86,98.31) ; P2.33 v1(53.23,59.34)
  BOTTOM w0.152: v1(53.23,59.34) 53.23,60.31 54.78,61.86 64.05,61.86 65.57,63.38 65.57,68.72 63.54,70.75 63.54,72.91 64.05,73.41 64.94,73.41 65.19,73.67 v1(66.46,73.67) ; v1(46.86,98.31) 47.6,98.31 50.8,95.11 61.1,95.11 61.89,94.32 63.87,94.32 v1(65.45,95.89)
UART2_PPS: length 47
  TOP w0.152: U2.8 v1(50.88,80.24) ; v1(54.02,73.67) 63.03,73.67 v1(64.05,72.65) ; P2.41 v1(55.23,59.37)
  BOTTOM w0.152: v1(54.02,73.67) 54.02,77.86 53.25,78.62 53.25,79.64 52.66,80.24 v1(50.88,80.24) ; v1(64.05,72.65) 64.94,72.65 65.12,72.48 65.12,70.47 66.33,69.25 66.33,63 64.43,61.1 56.17,61.1 55.23,60.16 v1(55.23,59.37)
UART2_RTS: length 83.6
  TOP w0.152: v1(64.05,71.87) 64.53,72.35 64.53,74.38 63.33,75.57 61,75.57 60.37,76.21 60.37,92.59 63.92,96.15 v1(63.92,98.05) ; U2.46 v1(42.86,98.31) ; P2.35 v1(53.73,58.84)
  BOTTOM w0.152: v1(63.92,98.05) 63.19,97.32 52.97,97.32 49.57,100.72 44.74,100.72 42.86,98.83 v1(42.86,98.31) ; v1(53.73,58.84) 53.73,59.8 55.41,61.48 64.18,61.48 65.95,63.25 65.95,69 64.05,70.9 v1(64.05,71.87)
UART2_RX: length 103.8
  TOP w0.152: P2.37 54.23,58.59 56.05,56.78 65.83,56.78 67.1,58.05 v1(71.67,58.05) ; U2.48 v1(41.86,98.26)
  BOTTOM w0.152: v1(71.67,58.05) 71.16,58.56 71.16,59.83 73.71,62.38 73.71,70.73 71.77,72.67 69.37,72.67 66.84,75.19 66.84,78.11 65.45,79.51 ; v1(41.86,98.26) 41.86,100.88 43.73,102.75 66.46,102.75 67.86,101.35 67.86,97.93 66.46,96.53
  BOTTOM w0.165: 65.45,79.51 65.45,85.86 66.46,86.88 66.46,96.53
UART2_TX: length 104.9
  TOP w0.152: U2.50 v1(40.86,98.28) ; v1(71.67,58.81) 67.32,58.81 65.67,57.16 56.43,57.16 54.73,58.85 P2.39
  BOTTOM w0.152: v1(71.67,58.81) 74.47,61.61 74.47,71.04 72.09,73.42 69.63,73.42 67.6,75.45 67.6,78.62 66.21,80.02 ; v1(40.86,98.28) 40.86,100.89 43.47,103.51 66.72,103.51 68.62,101.61 68.62,97.43 67.24,96.04 67.24,96.03
  BOTTOM w0.165: 66.21,80.02 66.21,85.35 67.24,86.38 67.24,96.03
UC_LED0: length 45.9
  TOP w0.152: R78.1 v1(3.85,84.08) ; U2.57 v1(37.36,97.78)
  BOTTOM w0.152: v1(3.85,84.08) 4.36,84.59 4.36,87.51 6.49,89.65 10.23,89.65 12.84,92.26 17.35,92.26 24.28,99.2 30.86,99.2 31.37,98.69 31.37,97.68 32.26,96.79 36.36,96.79 v1(37.36,97.78)
UC_LED1: length 51.6
  TOP w0.152: U2.44 v1(43.86,98.27) ; R79.1 v1(3.85,87.64)
  BOTTOM w0.152: v1(43.86,98.27) 43.86,97.47 43.56,97.17 40.19,97.17 38.8,98.56 37.15,98.56 35.76,97.17 32.38,97.17 31.75,97.8 31.75,98.82 30.99,99.58 24.16,99.58 17.2,92.62 12.59,92.62 10,90.03 6.24,90.03 v1(3.85,87.64)
UNNAMED_4_ADMAX31343_I226_CLKO: length 7.4
  TOP w0.152: R58.1 v1(16.8,69.73) ; U3.1 v1(12.91,67.99)
  BOTTOM w0.152: v1(12.91,67.99) 13.26,67.99 13.45,67.8 15.76,67.8 16.04,68.08 16.04,68.97 v1(16.8,69.73)
UNNAMED_4_ADMAX31343_I226_INTN: length 1.8
  TOP w0.152: U3.3 14.21,68.02 R60.1
UNNAMED_4_ADMAX31343_I226_SQW: length 1.8
  TOP w0.152: U3.4 14.86,67.99 R59.1
UNNAMED_4_ADMAX31343_I226_VBAT: length 3
  TOP w0.152: R56.1 14.94,74.85 14.21,74.12 U3.6
UNNAMED_4_CAP_I166_N1: length 0.9
  TOP w0.152: R126.1 C180.1
UNNAMED_4_DIOLED_I251_P: length 2.8
  TOP w0.152: DS1.A 6.04,81.7 5.76,81.42 4.99,81.42 4.74,81.16 4.74,80.53 R77.2
UNNAMED_4_DIOLED_I254_P: length 1.9
  TOP w0.152: R78.2 5.75,84.73 6.04,85.02 DS2.A
UNNAMED_4_DIOLED_I257_P: length 1.9
  TOP w0.152: R79.2 5.75,88.29 6.04,88.57 DS3.A
UNNAMED_6_CAP_I27_N2: length 2.5
  TOP w0.152: FB1.1 41.95,42.1 C45.2 43.02,42.05 C41.2
UNNAMED_6_DIOLED_I2_P: length 1.7
  TOP w0.152: R44.1 LED1.A
UNNAMED_6_DIOLED_I4_P: length 1.7
  TOP w0.152: R45.1 LED6.A
UNNAMED_6_DIOLED_I9_P: length 1.7
  TOP w0.152: R46.1 LED2.A
UNNAMED_6_DIOLED_I12_P: length 1.7
  TOP w0.152: R47.1 LED3.A
UNNAMED_6_DIOLED_I34_P: length 1.7
  TOP w0.152: R50.1 LED5.A
UNNAMED_7_CAP_I17_N2: length 3.5
  TOP w0.152: R24.2 R26.1 51.68,21.38 C28.2
UNNAMED_7_CAP_I20_N1: length 3.5
  TOP w0.152: C26.1 41.87,21.38 R25.1 R23.2
UNNAMED_7_CAP_I23_N2: length 3.5
  TOP w0.152: C22.2 39.36,21.38 R17.1 R15.2
UNNAMED_7_CAP_I32_N1: length 3.5
  TOP w0.152: C21.1 29.55,21.38 R16.1 R14.2
UNNAMED_7_CAP_I38_N2: length 3.5
  TOP w0.152: R6.2 R8.1 27.04,21.38 C18.2
UNNAMED_7_CAP_I40_N1: length 3.5
  TOP w0.152: C17.1 17.24,21.38 R7.1 R5.2
UNNAMED_7_CAP_I57_N2: length 3.5
  TOP w0.152: R22.2 R36.1 14.72,21.38 C16.2
UNNAMED_7_CAP_I58_N1: length 3.5
  TOP w0.152: R21.2 R35.1 4.92,21.38 C15.1
UNNAMED_7_CN2P_I113_N1: length 13.7
  TOP w0.152: P3.1 7.41,9.44 6.96,9.89 R1.1 6.96,13.78 7.73,14.55 7.73,15.57 8.02,15.86 Q2.2 Q1.1 8.87,18.21 R21.1
UNNAMED_7_CN2P_I113_N2: length 13.6
  TOP w0.152: R22.1 10.77,18.21 Q1.2 Q2.1 11.62,15.86 11.91,15.57 11.91,14.55 12.68,13.78 R2.2 12.68,9.72 12.41,9.44 P3.2
UNNAMED_7_CN2P_I114_N1: length 13.7
  TOP w0.152: P4.1 19.73,9.44 19.28,9.89 R3.1 19.28,13.78 20.05,14.55 20.05,15.57 20.34,15.86 Q4.2 Q3.1 21.19,18.21 R5.1
UNNAMED_7_CN2P_I114_N2: length 13.6
  TOP w0.152: R6.1 23.09,18.21 Q3.2 Q4.1 23.94,15.86 24.23,15.57 24.23,14.55 25,13.78 R4.2 25,9.72 24.73,9.44 P4.2
UNNAMED_7_CN2P_I115_N1: length 13.7
  TOP w0.152: R14.1 33.5,18.21 Q5.1 Q6.2 32.65,15.86 32.37,15.57 32.37,14.55 31.6,13.78 R10.1 31.6,9.89 32.04,9.44 P5.1
UNNAMED_7_CN2P_I115_N2: length 13.6
  TOP w0.152: P5.2 37.04,9.44 37.32,9.72 R11.2 37.32,13.78 36.55,14.55 36.55,15.57 36.26,15.86 Q6.1 Q5.2 35.41,18.21 R15.1
UNNAMED_7_CN2P_I116_N1: length 13.7
  TOP w0.152: P6.1 44.36,9.44 43.92,9.89 R19.1 43.92,13.78 44.69,14.55 44.69,15.57 44.97,15.86 Q9.2 Q7.1 45.82,18.21 R23.1
UNNAMED_7_CN2P_I116_N2: length 13.6
  TOP w0.152: P6.2 49.36,9.44 49.64,9.72 R20.2 49.64,13.78 48.86,14.55 48.86,15.57 48.58,15.86 Q9.1 Q7.2 47.73,18.21 R24.1
UNNAMED_7_CN4PABC_I117_N1: length 2.7
  BOTTOM w0.305: P8.1A L1.1
UNNAMED_7_CN4PABC_I117_N2: length 2.7
  BOTTOM w0.305: P8.2A L2.1
UNNAMED_7_CN4PABC_I117_N3: length 2.7
  BOTTOM w0.305: P8.3A L3.1
UNNAMED_7_CN4PABC_I117_N4: length 2.7
  BOTTOM w0.305: L4.1 P8.4A
UNNAMED_7_FERRITE_I70_N2: length 1.7
  BOTTOM w0.305: L3.2 R13.1
UNNAMED_7_FERRITE_I72_N2: length 1.7
  BOTTOM w0.305: L2.2 R12.1
UNNAMED_7_FERRITE_I89_N2: length 1.7
  BOTTOM w0.305: L1.2 R9.1
UNNAMED_7_RES_I119_N2: length 1.7
  BOTTOM w0.305: R9.2 R18.1
UNNAMED_7_RES_I120_N2: length 1.7
  BOTTOM w0.305: R18.2 R30.1
UNNAMED_7_RES_I121_N2: length 1.7
  BOTTOM w0.305: R30.2 R37.1
UNNAMED_7_RES_I123_N2: length 1.7
  BOTTOM w0.305: R12.2 R27.1
UNNAMED_7_RES_I124_N2: length 1.7
  BOTTOM w0.305: R27.2 R31.1
UNNAMED_7_RES_I125_N2: length 1.7
  BOTTOM w0.305: R31.2 R38.1
UNNAMED_7_RES_I127_N2: length 1.7
  BOTTOM w0.305: R13.2 R28.1
UNNAMED_7_RES_I128_N2: length 1.7
  BOTTOM w0.305: R28.2 R34.1
