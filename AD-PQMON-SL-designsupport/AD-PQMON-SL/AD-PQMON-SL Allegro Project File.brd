# Allegro board AD-PQMON-SL Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UNNAMED_7_RES_I129_N2: length 1.7
  BOTTOM w0.305: R34.2 R39.1
UNNAMED_8_ADLTC3306_I30_PGOOD: length 126
  TOP w0.152: U6.A1 71.22,75.65 v1(71.52,75.65) ; R64.2 v1(69.26,79.64)
  BOTTOM w0.152: v1(71.52,75.65) 71.22,75.65 69.26,77.61 v1(69.26,79.64) 69.26,84.46 68.75,84.97 68.75,95.39 70.14,96.78 70.14,102.12 67.22,105.04 24.17,105.04 22.37,103.23 22.37,98.29 17.05,92.97 12.39,92.97 9.82,90.41 3.32,90.41 2.58,89.67 2.58,77.4 3.6,76.39 5.81,76.39 TP12.1
UNNAMED_8_ADLTC3306_I30_SW: length 5.3
  TOP w0.165: U6.B2 69.51,76.46 69.13,76.08 69.13,75.19 70.65,73.67 L5.1
UNNAMED_8_CAP_I52_N1: length 3.6
  TOP w0.152: R76.2 R75.2 C11.1
UNNAMED_8_CN2P_I1_N1: length 62.6
  TOP w0.508: M1.3 95.42,59.7 94.53,58.81 94.53,51.7 95.42,50.81 98.26,50.81 99.1,49.97 99.1,34.63 91.13,26.65 91.13,11.46 92.58,10.01 P7.1
UNNAMED_8_CN2P_I1_N2: length 54.1
  TOP w0.508: P7.2 97.58,11.9 95.9,13.57 95.9,25.38 102.91,32.39 102.91,53.6 101.89,54.62 M1.1
UNNAMED_8_RES_I8_N2: length 7.1
  TOP w0.152: v1(72.18,98.31) 72.18,98.76 72.62,99.2 U17.4 ; v1(74.6,95.84) R51.2 R52.1
  BOTTOM w0.152: v1(74.6,95.84) 73.93,95.84 72.18,97.6 v1(72.18,98.31)
UNNAMED_8_RES_I23_N1: length 6.3
  TOP w0.152: v1(75.36,104.35) R48.2 R49.1 ; U17.8 75.24,100.96 v1(75.68,101.41)
  BOTTOM w0.152: v1(75.36,104.35) 75,103.99 75,101.74 75.33,101.41 v1(75.68,101.41)
UNNAMED_8_RES_I37_N2: length 2.2
  TOP w0.152: R63.2 70.15,88.22 69.54,87.61 Q8.1
UNNAMED_8_RES_I44_N1: length 3.3
  TOP w0.152: R69.1 R67.2 R68.2
UNNAMED_8_RES_I44_N2: length 41.8
  TOP w0.152: R74.1 R73.2 ; R73.2 88.51,96.7 C11.2 v1(88.56,95.51) ; R73.2 82.88,96.7 82.58,96.39 R70.1 R69.2 ; v1(71.54,77.28) 71.22,77.28 U6.C1
  BOTTOM w0.152: v1(88.56,95.51) 88.56,95.06 81.88,88.38 75.53,88.38 72.79,85.63 72.79,78.52 v1(71.54,77.28)
UNNAMED_8_RES_I50_N1: length 3.6
  TOP w0.152: R72.2 R71.2 R73.1
UNNAMED_9_CN16PAB4GND_I20_N3: length 3.7
  TOP w0.152: P10.A5 8.75,99.15 9.57,99.96 9.57,100.35 R157.2
USB_BUCK_EN: length 172.5
  TOP w0.152: R66.1 R65.2 71.3,83.46 71.77,83.93 Q8.3 v1(73.32,85.35) ; U6.B1 v1(71.54,76.46) ; U12.3 v1(95.05,93.83) ; U9.3 v1(94.34,98.81)
  BOTTOM w0.152: TP17.1 2.2,76.34 2.2,89.8 3.19,90.79 9.67,90.79 12.21,93.33 16.91,93.33 22.01,98.43 22.01,103.39 24.04,105.42 67.35,105.42 70.53,102.24 70.53,96.66 69.13,95.26 69.13,85.23 69.74,84.62 69.74,77.81 71.08,76.46 v1(71.54,76.46) 73.32,78.24 v1(73.32,85.35) 75.96,87.99 82.13,87.99 88.94,94.8 93.03,94.8 94,93.83 95.04,93.83 ; v1(94.34,98.81) 95.04,98.11 95.04,93.83 ; 95.04,93.83 v1(95.05,93.83)
USB_DN: length 17.4
  TOP w0.165: U2.83 25.62,89.24 25.61,89.25 25.58,89.25 24.62,90.21 21.14,90.21 20.61,90.73 20.61,97.16 20.19,97.59 18.7,97.59 18.51,97.4 L7.4
USB_DN_CM: length 9
  TOP w0.165: L7.3 15.36,97.4 15.16,97.59 14.2,97.59 14.03,97.42 14.03,97.2 13.87,97.04 D7.C 13.47,97.31 13.11,97.67 9.41,97.67 9.41,97.66 8.79,97.66 8.57,97.45 P10.A7
USB_DP: length 17.5
  TOP w0.165: L7.1 18.51,98.2 18.7,98.01 20.36,98.01 21.03,97.34 21.03,90.9 21.31,90.62 24.62,90.62 25.73,91.74 U2.78
USB_DP_CM: length 8.9
  TOP w0.165: L7.2 15.36,98.2 15.16,98.01 14.2,98.01 14.03,98.17 14.03,98.4 13.87,98.56 D6.C 13.47,98.29 13.26,98.08 9.24,98.08 9.24,98.08 8.79,98.08 8.57,98.3 P10.A6
VAN: length 59.9
  TOP w0.152: U1.19 v1(39.36,44.81)
  TOP w0.305: TP58.1 86.02,43.82 86.6,43.24 C52.2 86.65,42.24 86.65,38.07 85.66,37.08 C27.1 83.28,37.08 R33.1
  L3_PWR w0.152: TP58.1 82.57,43.82 80.69,41.94 56.54,41.94 56.19,42.3 41.19,42.3 39.87,43.62 39.87,44.3 v1(39.36,44.81)
VAP: length 73.9
  TOP w0.152: v1(40.12,44.94) 39.75,45.31 U1.20
  TOP w0.305: TP57.1 88.18,43.82 87.6,43.24 C52.1 87.54,42.24 87.54,38.07 88.53,37.08 C23.1 ; C23.1 88.66,37.06 v1(88.66,35.8) ; C23.1 90.92,37.08 R29.1
  L3_PWR w0.152: TP57.1 88.28,45.25 83.3,45.25 80.41,42.35 56.81,42.35 56.43,42.73 41.47,42.73 40.48,43.72 40.48,44.59 v1(40.12,44.94)
  BOTTOM w0.305: R37.2 v1(88.66,35.8)
VBN: length 51.1
  TOP w0.152: v1(38.52,47.63) 37.6,46.71 U1.21
  TOP w0.305: TP56.1 76.24,43.82 76.82,43.24 C54.2 76.88,42.24 76.88,38.07 75.89,37.08 C35.1 73.5,37.08 R41.1
  L3_PWR w0.152: v1(38.52,47.63) 39.82,47.63 42.56,44.89 73.65,44.89 TP56.1
VBP: length 63
  TOP w0.152: U1.22 37.1,46.74 38.01,47.66 v1(38.01,48.14)
  TOP w0.305: v1(78.88,35.8) 78.88,37.06 C33.1 ; C33.1 78.76,37.08 77.76,38.07 77.76,42.24 C54.1 77.82,43.24 78.4,43.82 TP55.1 ; C33.1 81.14,37.08 R32.1
  L3_PWR w0.152: TP55.1 78.43,45.32 42.76,45.32 39.94,48.14 v1(38.01,48.14)
  BOTTOM w0.305: R38.2 v1(78.88,35.8)
VCN: length 39.8
  TOP w0.152: U1.23 v1(36.6,47.36)
  TOP w0.305: TP54.1 62.73,43.82 63.17,43.38 C55.2 63.17,37.94 62.31,37.08 C36.1 58.76,37.08 R42.1
  L3_PWR w0.152: TP54.1 57.52,43.82 56.91,44.43 42.28,44.43 39.69,47.02 36.93,47.02 v1(36.6,47.36)
VCP: length 53.5
  TOP w0.152: v1(36.55,48.08) 36.1,47.62 U1.24
  TOP w0.305: 68.6,37.11 68.57,37.08 C34.1 64.92,37.08 64.17,37.84 C55.1 64.17,43.41 64.58,43.82 TP53.1 ; 68.6,37.11 v1(68.6,35.8) ; 68.6,37.11 R40.1
  L3_PWR w0.152: v1(36.55,48.08) 36.03,47.56 36.03,47.05 36.57,46.52 39.54,46.52 42.08,43.98 56.53,43.98 57.78,42.73 66.26,42.73 TP53.1
  BOTTOM w0.305: R39.2 v1(68.6,35.8)
VPWR_USB: length 16.5
  TOP w0.254: U6.C2 70.4,77.66
  TOP w0.305: 70.4,77.66 71.15,78.41 R64.1 71.15,80.73 C9.1 v1(73.85,81.03) ; R65.1 v1(73.85,82.43)
  TOP w0.635: C8.P v1(75.08,54.11) ; C8.P v1(76.65,55.84) ; C8.P v1(75.08,57.57) ; v1(5.76,104.15) D10.C
  L3_PWR w0.457: P10.A9 8.78,95.75 ; P10.A4 8.76,100
XIN_ADE: length 10.5
  TOP w0.152: X2.1 27.14,49.23 29.27,49.23 C38.1 29.63,49.24 32.24,49.24 33.6,47.89 U1.29
XOUT_ADE: length 7.6
  TOP w0.152: U1.30 33.1,47.67 32.07,48.7 29.64,48.7 C37.1 29.29,48.68 28.48,48.68 X2.3

## Copper pours and planes (outline as drawn)
1V1 on TOP: 74.95,100.03 76.04,100.03 76.39,100.39 77.87,100.39 77.99,100.52 77.99,101.05 77.87,101.18 76.14,101.18 75.58,100.62 74.95,100.62
1V1 on L3_PWR: 76.01,102.62 52.92,102.62 50.08,99.78 50.08,97.21 45.28,92.41 45.28,86.85 46.7,85.43 51.17,85.43 51.17,77.86 45.25,77.86 39.72,83.4 28.51,83.4 24.32,87.59 24.32,89.32 24.73,89.72 42,89.72 42,97.21 45.56,100.77 45.56,105.55 79.26,105.55 79.26,100.52 76.01,100.52
1V8 on TOP: 74.82,99.25 74.82,98.59 75.17,98.23 75.17,97.37 76.47,97.37 76.62,97.52 76.62,98.38 75.66,99.35 74.92,99.35
1V8 on BOTTOM: 39.26,97.72 39.26,92.39 42.18,89.47 47.31,89.47 47.95,88.83 47.95,87.16 47.39,86.6 42.18,86.6 39.26,83.68 39.26,76.08 37.07,73.9 29.68,73.9 29.53,73.75 29.53,72.98 30.42,72.09 30.42,71.08 26.28,71.08 24.37,72.98 24.37,79.99 26.23,79.99 26.81,80.58 26.81,85.71 26.58,85.94 17.67,85.94 17.67,88.88 25.57,96.78 36.74,96.78 38.01,98.05 38.93,98.05
1V8 on L3_PWR: 76.75,98.46 76.75,97.52 76.72,97.49 72.61,97.49 72,98.1 72,99.65 70.45,99.65 66.33,95.54 58.31,95.54 55.69,92.92 55.69,87.03 54.5,85.84 46.88,85.84 45.66,87.05 45.66,94.67 53.1,102.12 75.5,102.12 75.5,99.7
3V3 on L3_PWR: 81.7,103.03 93.44,103.03 93.44,100.59 91.73,100.59 91.73,95.89 82.39,95.89 76.82,90.33 67.81,90.33 67.81,54.64 47.44,54.64 46.85,55.23 46.85,57.34 46.4,57.79 6.26,57.79 6.26,88.12 6.85,88.71 16.12,88.71 17.31,89.9 17.31,93.76 21.88,98.33 26.71,98.33 26.71,105.55 81.7,105.55
3V3_USB on L3_PWR: 82.08,105.55 82.08,103.41 93.82,103.41 93.82,100.21 92.12,100.21 92.12,95.51 82.72,95.51 77.03,89.82 68.06,89.82 68.06,53.88 70.98,53.88 79.67,62.57 79.67,70.82 73.09,77.4 73.09,83.37 87.54,83.37 87.54,91.7 87.62,91.88 87.8,91.96 103.8,91.96 103.8,105.42 103.67,105.55
3V3_WALL on TOP: 70.04,91.37 78.98,91.37 78.98,89.75 77.16,87.92 70.83,87.92 70.83,88.83 70.7,88.83 70.04,89.49
+3V3_ADE on L3_PWR: 1.02,1.02 52.8,1.02 52.8,21.47 58.13,26.81 58.13,47.89 43.8,47.89 37.48,54.21 1.02,54.21
DGND on TOP: 87.54,52.94 45.89,52.94 41.67,57.16 0.76,57.16 0.76,105.92 104.14,105.92 104.14,91.96 87.8,91.96 87.54,91.7 ; 1 cut-out
DGND on BOTTOM: 0.76,105.92 0.76,57.16 41.65,57.16 42.97,55.84 42.97,51.32 43.04,51.14 43.22,51.06 87.29,51.06 87.47,51.14 87.54,51.32 87.54,91.7 87.62,91.88 87.8,91.96 104.14,91.96 104.14,105.92 ; 19 cut-outs
DGND on L2_GND: 0.76,105.92 104.14,105.92 104.14,91.32 103.89,91.07 88.67,91.07 88.43,90.83 88.43,49.92 45.86,49.92 39.51,56.27 0.76,56.27
GND on TOP: 60.2,16.39 53.25,16.39 53.25,0.76 0.76,0.76 0.76,54.11 39.66,54.11 39.84,54.04 39.92,53.86 39.92,48.55 40.45,48.01 93.39,48.01 94.12,47.28 94.12,39.18 93.21,38.26 60.88,38.26 60.2,37.58
GND on BOTTOM: 60.2,16.39 53.25,16.39 53.25,0.76 0.76,0.76 0.76,54.11 39.66,54.11 39.84,54.04 39.92,53.86 39.92,48.83 40.73,48.01 93.39,48.01 94.12,47.28 94.12,39.18 93.21,38.26 60.88,38.26 60.2,37.58 ; 10 cut-outs
GND on L2_GND: 63.41,16.14 53.25,16.14 53.25,0.76 0.76,0.76 0.76,54.11 37.43,54.11 43.53,48.01 93.39,48.01 94.12,47.28 94.12,39.18 93.21,38.26 64,38.26 63.41,37.68
VPWR_USB on L3_PWR: 45.35,50.28 38.47,57.16 1.06,57.16 1.06,105.42 1.18,105.55 22.52,105.55 22.8,105.27 22.8,99.07 21.88,99.07 16.3,93.48 16.3,89.77 15.92,89.39 6.54,89.39 5.25,88.1 5.25,76.23 8.02,73.47 8.02,70.24 14.65,63.61 28.54,63.61 32.76,59.39 32.76,59.37 43.42,59.37 46.32,56.47 46.32,54.75 47.56,53.5 70.65,53.5 80.18,63.03 80.18,71.03 73.6,77.61 73.6,82.89 87.54,82.89 87.54,51.67 86.15,50.28

## Text on the board
User.Comments: 4.    RoHS COMPLIANCE: ASSEMBLY VENDOR SHOULD ASSURE COMPLIANCE | 5.    BOARDS TO BE SHIPPED SINGULATED AFTER ASSEMBLY PROCESS. | 6.    SMOOTHEN EDGES AND FREE FROM BURRS AFTER DEPANELIZATION. | DIRECTIVE 2002/95/EC). | WITH LEAD-FREE AND RoHS PCB ASSEMBLY STANDARDS (EU RoHS | (2 PLACES) | DETAIL A
Ref Des/Silkscreen Top: C | A | IAP | IAN | IBP | IBN | PRIMARY SIDE | 08-080779 REV A Z | ADE9430/MAX32650 | ICP | ICN | INP | INN | VN | VC | VB | VA
DIMENSION: "" | (REF) | DIA MAX | SEE NOTE 20
BODY_CENTER: FAB NOTES REVISION: 2ND NOVEMBER 2022 | 8.   IMPEDANCE REQUIREMENTS: IF NO STACKUP IS DEFINED, THE VENDOR IS ALLOWED TO ADJUST THE DIELECTRIC | 13.  PLATING SPECIFICATION: | 9.   FILLET OPTIONS TO ENHANCE RELIABILITY AT PAD JUNCTIONS WHERE SPACING PERMITS. | 10.  THIEVING: | 11.  LAYER TO LAYER REGISTRATION SHALL BE WITHIN 0.003 INCHES. | 12.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN 0.005 INCHES DTP,UNLESS SPECIFIED. | 14.  SURFACE FINISH: | 15.  SOLDERMASK: | 1.   DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | ALL DOCUMENTS & SPECIFICATIONS REFERRED TO BELOW SHOULD BE THE LATEST REVISIONS. | 2.  BOARD MATERIAL:(USE CHECKED ITEMS) | 3.   ALL LAMINATES & BONDING MATERIALS SHOULD BE SELECTED FROM IPC-4101 OR IPC-4103,(TG>170 DEGC TD>300 DEGC) | 4.   REFER TO IPC-6010 SERIES, CLASS 2 FOR FABRICATION. | 5.   REFER TO LAMINATION DIAGRAM FOR OVERALL BOARD THICKNESS, TOLERANCE APPLIES AFTER ALL LAMINATION AND PLATING | 6.   BOW & TWIST NOT TO EXCEED 0.0075 INCHES (0.75%) PER LINEAR INCH AND SHOULD BE MEASURED PER IPC-TM-650, METHOD 2.4.22. | 7.   ACCEPTABILITY PER ADI SPECIFICATION TST00115. | 16.  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, EPOXY BASED INK PER ARTWORK. | ( ) FILLETS ALLOWED | (X) FILLETS NOT ALLOWED | ( ) VENDOR MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS MAINTAINING A MINIMUM | (X) VENDOR MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS. | (X) LPI | ( ) OTHER_________ | COLOR | (X) GREEN | (X) WHITE | ( ) OTHER | HINDER PROPER SOLDER WICKING. BARREL RELIEF ON SOLDERMASK ALLOWED IN UNFILLED VIA IN PAD HOLES. | (X) REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIRMENTS | (X) IMMERSION GOLD (ENIG) 1.58-3.94 MICRO INCHES OVER 118-236 MICRO INCHES MIN. OF ELECTROLESS NICKEL PER IPC-4552 | ( ) OSP (ORGANIC SOLDERABILITY PRESERVATIVE) | ( ) IMMERSION SILVER | ( ) SOFT WIRE BONDABLE GOLD 30-50 MICRO INCHES OF SOFT WIRE | ( ) EDGE CONNECTOR FINGERS ARE TO BE PLATED WITH 100 MICRO-INCHES(.0001") OF LOW STRESS | THICKNESS & TRACE WIDTHS TO MEET THE IMPEDANCE REQUIREMENT. IF SPECIFIED, THE VENDOR MUST | TRACE WIDTH & SPACING THAT IMPACT THE REQUIREMENTS MUST HAVE WRITTEN APPROVAL FROM ADI. | MINIMUM BARREL PLATING OF 0.001 INCHES. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR SO AS TO | SOLDERMASK OVER BARE COPPER OR BARE GOLD (BOTH SIDES) TO MEET IPC-SM-840. | IF PRESENT,DO NOT MODIFY SOLDERMASK DEFINED PADS (MASK OPENINGS LESS THAN COPPER PAD) WITHOUT APPROVAL. | MEET THE REQUIREMENTS LISTED IN THE IMPEDANCE TABLE. ANY ADJUSTMENT MADE TO THE DEFINED STACKUP, | PROCESSES. FINISHED THICKNESS MEASURED FROM TOP COPPER TO BOTTOM COPPER. | (X)  ISOLA 370HR OR S1000-2 OR IT180 OR EQUIVALENT | ( )  ISOLA-FR408HR OR EQUIVALENT | ( )  ISOLA IS410 | ( )  MEGTRON 6 | ( )  NELCO-4000-13 | ( )  ROGERS 4350B | ( ) ROGERS 3003 | ( ) ARLON 85N | ( ) EM370D | ( )  OTHER ________________________ | UL FLAMMABILITY RATING 94V-0. BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796/UL796F. | BONDABLE GOLD OVER 100-150 MICRO INCHES OF NICKEL | NICKEL UNDER 30 MICRO-INCHES (.0003') OF GOLD | 0.100 INCH CLEARANCE FROM ALL COPPER FEATURES, | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. | UNLESS OTHERWISE SPECIFIED | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLAINT WITH THE EU DIRECTIVE 2002/95/EC | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2. | 21.  INTENTIONAL SHORTS: | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 22.  PEMNUTS: | 23.  MANUFACTURER TO ETCH/STAMP WITH PERMANENT NON-CONDUCTIVE INK | ON SECONDARY SIDE UNLESS OTHERWISE SPECIFIED: | 18.  A TIME DOMAIN REFLECTOMETER REPORT (TDR) FOR EACH IMPEDANCE CONTROLLED LAYER & A CERTIFICATE | 19.  IF PRESENT, ALL BLIND/BURIED VIAS WITH AN ASPECT RATIO <1:1 TO BE PLATED SHUT WITH COPPER WHEN | 20.  FOR VIA FILL INFORMATION REFER TO DRILL CHART: | 24. PANELIZATION: | 25.  MINIMUM DESIGN LINE WIDTH IS .006 INCH. | 26.  MINIMUM DESIGN LINE SPACING IS .006 INCH. | IS ACCEPTABLE, ALL OTHER INSTANCES MUST BE REPORTED. | IF AN INTENTIONAL SHORT REPORT IS SUPPLIED AND DOES NOT MATCH THE FAB DATA THEN | THE PCB SHALL HAVE A VERIFICATION STAMP. | (X)  NON-CONDUCTIVE EPOXY FILL ALL 0.010 INCHES DRILLED VIAS | ( )  COPPER FILL ALL 0.XXXX INCHES DRILLED VIAS | ( ) PEMNUTS TO BE INSTALLED BY FABRICATOR | ( ) PEMNUTS NOT TO BE INSTALLED BY FABRICATOR | (X) NOT APPLICABLE | USED AS VIA-IN-PAD OR AS A STACKED VIA. BLIND/BURIED VIAS WITH AN ASPECT RATIO >1:1 TO BE FILLED | A. UL CODE-FLAMMABILITY RATING FOR THOSE APPROVED MATERIALS(IF APPLICABLE) | B. DATE CODE | C. LOT NUMBER | D. MANUFACTURER LOGO | BOARDS TO BE SHIPPED IN ARRAY AND KEPT INTACT | PANEL TO BE SUBJECTED TO CUSTOMERS APPROVAL | PANEL SOLDER PASTE STENCIL GERBER TO BE PROVIDED TO ANALOG | CAN'T BE PERFORMED BECAUSE THE TRACE LENGTH IS TOO SHORT ON THE OUTER LAYERS AT THE PIN ESCAPES | ADI APPROVAL IS REQUIRED. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. INSTANCES WHERE TDR TESTING | WITH NON-CONDUCTIVE EPOXY. | 4-LAYER STACKUP | TOOLING: | FINISH: | NOTES: | MATERIAL: | TESTING: | MISCELLANEOUS:
PAGE_OUTLINE: C.CARBUNARU | K.JABATAN | N.CATALAN | J.MALAYBA | M.VALE | 07FEB24 | LABEL PLACEMENT INFORMATION | HALF SIZE LABELS ARE | AVAILABLE IN THE LIBRARY | PLACE WHEELIE BIN LOGO | TO SUIT THE LAYOUT. | PLACE ROHS COMPLIANT LOGO | TO SUIT THE LAYOUT OR | DELETE IF NOT REQ'D. | PLACE CHINA ROHS COMPLIANT | LOGO TO SUIT THE LAYOUT OR | 1.THE BOARD SIZE CAN BE ADJUSTED TO SUIT THE APPLICATION. | 2.THE MOUNTING HOLES CAN BE MOVED/REMOVED TO SUIT THE APPLICATION. | 3.THE FIDUCIALS CAN BE MOVED TO SUIT THE APPLICATION. | 4.ADJUST THE DIMENSIONS TO SUIT THE APPLICATION. | 5.ADD THE CORRECT LAYER STACKUP ON FAB2 BASED ON THE NO OF LAYERS ON THE PCB. | 6.THE ROHS COMPLIANT AND WHEELIE BIN LOGO'S CAN BE MOVED TO THE DESIRED LOCATION. | HALF SIZE VERSIONS OF THE LABELS ARE AVAILABLE IN THE LIBRARY. | NOTES FOR TEMPLATE USAGE. | GENERIC D-SIZE TEMPLATE BR-067706A | CUSTOMER EVAL BOARD Z | ADE9430/MAX32650
User.11: C | A
User.17: L2 GND | 08-      -07
User.18: L3 PWR | 08-      -08
User.19: L3 GND | 08-      -09
User.24: DAUGHTER BOARD OUTLINE | REFERENCE ONLY
User.45: FIGURE | SIZE | 10.0 | 16.0 | 35.0 | 40.0 | 60.0 | 65.0 | 135.0 | 63.0x28.0 | 79.0x28.0 | PLATED | NON-PLATED | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | QTY | 799 | 16 | 5 | 38 | 12 | 10 | 2 | TOLERANCE/NOTES
